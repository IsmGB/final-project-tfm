* NGSPICE file created from alu.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_1 abstract view
.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_1 abstract view
.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_1 abstract view
.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_2 abstract view
.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_1 abstract view
.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_1 abstract view
.subckt sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_1 abstract view
.subckt sky130_fd_sc_hd__or3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_4 abstract view
.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_1 abstract view
.subckt sky130_fd_sc_hd__xor2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_1 abstract view
.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_1 abstract view
.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_1 abstract view
.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2b_1 abstract view
.subckt sky130_fd_sc_hd__or2b_1 A B_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_2 abstract view
.subckt sky130_fd_sc_hd__xnor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311o_1 abstract view
.subckt sky130_fd_sc_hd__a311o_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_1 abstract view
.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_1 abstract view
.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2a_1 abstract view
.subckt sky130_fd_sc_hd__o2bb2a_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111oi_2 abstract view
.subckt sky130_fd_sc_hd__a2111oi_2 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_2 abstract view
.subckt sky130_fd_sc_hd__nor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_1 abstract view
.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_1 abstract view
.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_4 abstract view
.subckt sky130_fd_sc_hd__nor3_4 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3b_1 abstract view
.subckt sky130_fd_sc_hd__nand3b_1 A_N B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_4 abstract view
.subckt sky130_fd_sc_hd__nor2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_1 abstract view
.subckt sky130_fd_sc_hd__a21bo_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_2 abstract view
.subckt sky130_fd_sc_hd__xor2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_1 abstract view
.subckt sky130_fd_sc_hd__xnor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_2 abstract view
.subckt sky130_fd_sc_hd__a22oi_2 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux4_1 abstract view
.subckt sky130_fd_sc_hd__mux4_1 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221oi_2 abstract view
.subckt sky130_fd_sc_hd__a221oi_2 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_1 abstract view
.subckt sky130_fd_sc_hd__a21boi_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_2 abstract view
.subckt sky130_fd_sc_hd__or4_2 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_1 abstract view
.subckt sky130_fd_sc_hd__nand4_1 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111o_1 abstract view
.subckt sky130_fd_sc_hd__a2111o_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31a_1 abstract view
.subckt sky130_fd_sc_hd__o31a_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_1 abstract view
.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_1 abstract view
.subckt sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_1 abstract view
.subckt sky130_fd_sc_hd__o22a_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_1 abstract view
.subckt sky130_fd_sc_hd__o211a_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_4 abstract view
.subckt sky130_fd_sc_hd__clkinv_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o41a_1 abstract view
.subckt sky130_fd_sc_hd__o41a_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_2 abstract view
.subckt sky130_fd_sc_hd__nand3_2 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4bb_1 abstract view
.subckt sky130_fd_sc_hd__and4bb_1 A_N B_N C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_6 abstract view
.subckt sky130_fd_sc_hd__buf_6 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4b_2 abstract view
.subckt sky130_fd_sc_hd__or4b_2 A B C D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_4 abstract view
.subckt sky130_fd_sc_hd__xnor2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32oi_2 abstract view
.subckt sky130_fd_sc_hd__a32oi_2 A1 A2 A3 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32o_1 abstract view
.subckt sky130_fd_sc_hd__a32o_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4b_4 abstract view
.subckt sky130_fd_sc_hd__or4b_4 A B C D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_2 abstract view
.subckt sky130_fd_sc_hd__or2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o311a_1 abstract view
.subckt sky130_fd_sc_hd__o311a_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31a_2 abstract view
.subckt sky130_fd_sc_hd__o31a_2 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o32a_1 abstract view
.subckt sky130_fd_sc_hd__o32a_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_1 abstract view
.subckt sky130_fd_sc_hd__a211o_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_2 abstract view
.subckt sky130_fd_sc_hd__nand2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_4 abstract view
.subckt sky130_fd_sc_hd__or4_4 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_4 abstract view
.subckt sky130_fd_sc_hd__or3_4 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22ai_1 abstract view
.subckt sky130_fd_sc_hd__o22ai_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4b_1 abstract view
.subckt sky130_fd_sc_hd__or4b_1 A B C D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_2 abstract view
.subckt sky130_fd_sc_hd__and2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111oi_4 abstract view
.subckt sky130_fd_sc_hd__a2111oi_4 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ba_1 abstract view
.subckt sky130_fd_sc_hd__o21ba_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_1 abstract view
.subckt sky130_fd_sc_hd__or4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4bb_4 abstract view
.subckt sky130_fd_sc_hd__or4bb_4 A B C_N D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_1 abstract view
.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111ai_4 abstract view
.subckt sky130_fd_sc_hd__o2111ai_4 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_1 abstract view
.subckt sky130_fd_sc_hd__and4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221o_1 abstract view
.subckt sky130_fd_sc_hd__a221o_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_2 abstract view
.subckt sky130_fd_sc_hd__o21ai_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_1 abstract view
.subckt sky130_fd_sc_hd__nor3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221a_1 abstract view
.subckt sky130_fd_sc_hd__o221a_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211oi_1 abstract view
.subckt sky130_fd_sc_hd__a211oi_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_4 abstract view
.subckt sky130_fd_sc_hd__o21ai_4 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_1 abstract view
.subckt sky130_fd_sc_hd__or3b_1 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_2 abstract view
.subckt sky130_fd_sc_hd__a21oi_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_1 abstract view
.subckt sky130_fd_sc_hd__o21bai_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31ai_2 abstract view
.subckt sky130_fd_sc_hd__o31ai_2 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s2s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_2 abstract view
.subckt sky130_fd_sc_hd__or3_2 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_4 abstract view
.subckt sky130_fd_sc_hd__or3b_4 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_1 abstract view
.subckt sky130_fd_sc_hd__a22oi_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux4_2 abstract view
.subckt sky130_fd_sc_hd__mux4_2 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_1 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_2 abstract view
.subckt sky130_fd_sc_hd__or3b_2 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_1 abstract view
.subckt sky130_fd_sc_hd__nand3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41o_1 abstract view
.subckt sky130_fd_sc_hd__a41o_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_1 abstract view
.subckt sky130_fd_sc_hd__o211ai_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_2 abstract view
.subckt sky130_fd_sc_hd__nand4_2 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_2 abstract view
.subckt sky130_fd_sc_hd__and3_2 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4b_1 abstract view
.subckt sky130_fd_sc_hd__and4b_1 A_N B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_2 abstract view
.subckt sky130_fd_sc_hd__a31o_2 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_2 abstract view
.subckt sky130_fd_sc_hd__mux2_2 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_4 abstract view
.subckt sky130_fd_sc_hd__a22oi_4 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_2 abstract view
.subckt sky130_fd_sc_hd__nand2b_2 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3b_1 abstract view
.subckt sky130_fd_sc_hd__nor3b_1 A B C_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_4 abstract view
.subckt sky130_fd_sc_hd__a21oi_4 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31ai_1 abstract view
.subckt sky130_fd_sc_hd__o31ai_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221ai_4 abstract view
.subckt sky130_fd_sc_hd__o221ai_4 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_2 abstract view
.subckt sky130_fd_sc_hd__o21bai_2 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4b_4 abstract view
.subckt sky130_fd_sc_hd__nand4b_4 A_N B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd1_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd1_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311oi_4 abstract view
.subckt sky130_fd_sc_hd__a311oi_4 A1 A2 A3 B1 C1 VGND VNB VPB VPWR Y
.ends

.subckt alu VGND VPWR control[0] control[1] control[2] control[3] data_in1[0] data_in1[10]
+ data_in1[11] data_in1[12] data_in1[13] data_in1[14] data_in1[15] data_in1[16] data_in1[17]
+ data_in1[18] data_in1[19] data_in1[1] data_in1[20] data_in1[21] data_in1[22] data_in1[23]
+ data_in1[24] data_in1[25] data_in1[26] data_in1[27] data_in1[28] data_in1[29] data_in1[2]
+ data_in1[30] data_in1[31] data_in1[3] data_in1[4] data_in1[5] data_in1[6] data_in1[7]
+ data_in1[8] data_in1[9] data_in2[0] data_in2[10] data_in2[11] data_in2[12] data_in2[13]
+ data_in2[14] data_in2[15] data_in2[16] data_in2[17] data_in2[18] data_in2[19] data_in2[1]
+ data_in2[20] data_in2[21] data_in2[22] data_in2[23] data_in2[24] data_in2[25] data_in2[26]
+ data_in2[27] data_in2[28] data_in2[29] data_in2[2] data_in2[30] data_in2[31] data_in2[3]
+ data_in2[4] data_in2[5] data_in2[6] data_in2[7] data_in2[8] data_in2[9] data_out[0]
+ data_out[10] data_out[11] data_out[12] data_out[13] data_out[14] data_out[15] data_out[16]
+ data_out[17] data_out[18] data_out[19] data_out[1] data_out[20] data_out[21] data_out[22]
+ data_out[23] data_out[24] data_out[25] data_out[26] data_out[27] data_out[28] data_out[29]
+ data_out[2] data_out[30] data_out[31] data_out[3] data_out[4] data_out[5] data_out[6]
+ data_out[7] data_out[8] data_out[9]
X_2037_ _0461_ _0693_ _0511_ VGND VGND VPWR VPWR _1139_ sky130_fd_sc_hd__o21a_1
XFILLER_0_27_60 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2106_ _0064_ _0066_ VGND VGND VPWR VPWR _0067_ sky130_fd_sc_hd__or2_1
XTAP_199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_81 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_55_317 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_63_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xrebuffer7 _1026_ VGND VGND VPWR VPWR net107 sky130_fd_sc_hd__buf_1
XFILLER_0_48_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_3_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1270_ net21 VGND VGND VPWR VPWR _0390_ sky130_fd_sc_hd__inv_2
X_1606_ _0553_ _0722_ _0552_ VGND VGND VPWR VPWR _0723_ sky130_fd_sc_hd__o21a_1
XFILLER_0_1_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_14_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1399_ net12 _0442_ _0471_ VGND VGND VPWR VPWR _0519_ sky130_fd_sc_hd__a21oi_1
X_1468_ _0481_ _0580_ _0585_ _0586_ VGND VGND VPWR VPWR _0587_ sky130_fd_sc_hd__a22o_1
X_1537_ net16 _0653_ _0654_ VGND VGND VPWR VPWR _0656_ sky130_fd_sc_hd__or3_1
XFILLER_0_52_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_45_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_18_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_50_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_339 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_59_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1322_ _0441_ VGND VGND VPWR VPWR _0442_ sky130_fd_sc_hd__buf_4
X_1253_ net47 VGND VGND VPWR VPWR _0373_ sky130_fd_sc_hd__inv_2
X_1184_ _0146_ net66 VGND VGND VPWR VPWR _0304_ sky130_fd_sc_hd__xor2_1
XFILLER_0_46_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_19_317 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_52_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_320 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_61_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_45_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_0_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1940_ _0993_ _0700_ _0699_ VGND VGND VPWR VPWR _1046_ sky130_fd_sc_hd__o21ai_1
X_1871_ _0977_ _0978_ VGND VGND VPWR VPWR _0979_ sky130_fd_sc_hd__and2_1
XFILLER_0_9_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_16_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_3_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_10_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1305_ _0424_ VGND VGND VPWR VPWR _0425_ sky130_fd_sc_hd__buf_2
X_1236_ net15 net47 VGND VGND VPWR VPWR _0356_ sky130_fd_sc_hd__or2_1
X_2285_ _0352_ _0234_ _0219_ VGND VGND VPWR VPWR _0256_ sky130_fd_sc_hd__a21o_1
X_1167_ net27 net59 VGND VGND VPWR VPWR _0283_ sky130_fd_sc_hd__or2b_1
XFILLER_0_19_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_30_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_38_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2070_ net17 _0028_ VGND VGND VPWR VPWR _0029_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_56_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1785_ _0458_ _0886_ _0887_ _0890_ _0896_ VGND VGND VPWR VPWR _0897_ sky130_fd_sc_hd__a311o_1
X_1854_ _0961_ _0962_ _0512_ VGND VGND VPWR VPWR _0963_ sky130_fd_sc_hd__mux2_1
XFILLER_0_24_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1923_ net114 VGND VGND VPWR VPWR _1029_ sky130_fd_sc_hd__inv_2
XFILLER_0_16_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_12_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_34_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2199_ _0162_ _0164_ VGND VGND VPWR VPWR _0165_ sky130_fd_sc_hd__xor2_1
X_1219_ net17 net49 VGND VGND VPWR VPWR _0339_ sky130_fd_sc_hd__or2_1
X_2268_ _0420_ _0236_ _0237_ VGND VGND VPWR VPWR _0238_ sky130_fd_sc_hd__and3_1
XFILLER_0_62_289 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_62_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_15_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_38_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1570_ _0511_ _0680_ _0687_ _0565_ VGND VGND VPWR VPWR _0688_ sky130_fd_sc_hd__o2bb2a_1
XTAP_348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2053_ _1112_ _0011_ _0505_ VGND VGND VPWR VPWR _0012_ sky130_fd_sc_hd__mux2_1
XTAP_359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2122_ _0382_ _0062_ VGND VGND VPWR VPWR _0084_ sky130_fd_sc_hd__or2_1
XFILLER_0_20_9 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xrebuffer17 _1054_ VGND VGND VPWR VPWR net117 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_32_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1837_ _0463_ _0467_ VGND VGND VPWR VPWR _0947_ sky130_fd_sc_hd__or2_1
X_1906_ _0615_ _0606_ VGND VGND VPWR VPWR _1013_ sky130_fd_sc_hd__or2_1
X_1768_ _0752_ _0805_ _0815_ _0814_ _0861_ VGND VGND VPWR VPWR _0880_ sky130_fd_sc_hd__a2111oi_2
X_1699_ net65 _0812_ VGND VGND VPWR VPWR _0813_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_12_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput75 net75 VGND VGND VPWR VPWR data_out[15] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_53_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput97 net97 VGND VGND VPWR VPWR data_out[6] sky130_fd_sc_hd__clkbuf_4
Xoutput86 net86 VGND VGND VPWR VPWR data_out[25] sky130_fd_sc_hd__clkbuf_4
X_1622_ _0629_ _0631_ VGND VGND VPWR VPWR _0739_ sky130_fd_sc_hd__or2_1
X_1484_ net62 _0564_ VGND VGND VPWR VPWR _0603_ sky130_fd_sc_hd__nor2_2
X_1553_ _0408_ _0656_ _0655_ VGND VGND VPWR VPWR _0671_ sky130_fd_sc_hd__a21o_1
XTAP_178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2036_ _0948_ _1137_ _0290_ VGND VGND VPWR VPWR _1138_ sky130_fd_sc_hd__mux2_1
XFILLER_0_27_72 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2105_ _0029_ _0037_ _0065_ VGND VGND VPWR VPWR _0066_ sky130_fd_sc_hd__o21a_1
XFILLER_0_64_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_23_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_109 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xrebuffer8 net125 VGND VGND VPWR VPWR net108 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_48_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1536_ _0653_ _0654_ net16 VGND VGND VPWR VPWR _0655_ sky130_fd_sc_hd__o21a_1
X_1605_ _0699_ _0714_ _0721_ _0566_ VGND VGND VPWR VPWR _0722_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_1_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_22_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1398_ _0516_ _0517_ VGND VGND VPWR VPWR _0518_ sky130_fd_sc_hd__or2_1
X_1467_ _0480_ _0564_ VGND VGND VPWR VPWR _0586_ sky130_fd_sc_hd__nor2_1
XFILLER_0_49_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2019_ _0768_ _1121_ VGND VGND VPWR VPWR _1122_ sky130_fd_sc_hd__nand2_1
XFILLER_0_60_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_60_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_45_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_13_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_28_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1252_ net52 VGND VGND VPWR VPWR _0372_ sky130_fd_sc_hd__inv_2
X_1321_ _0436_ _0439_ _0440_ VGND VGND VPWR VPWR _0441_ sky130_fd_sc_hd__nor3_4
XFILLER_0_19_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1183_ _0298_ _0302_ VGND VGND VPWR VPWR _0303_ sky130_fd_sc_hd__nand2_1
XFILLER_0_46_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_42_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_27_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1519_ _0425_ _0541_ VGND VGND VPWR VPWR _0638_ sky130_fd_sc_hd__or2_1
XFILLER_0_4_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_45_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_28_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_9_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1870_ net8 _0976_ VGND VGND VPWR VPWR _0978_ sky130_fd_sc_hd__or2_1
XFILLER_0_50_9 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_24_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_3_237 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_10_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1304_ _0241_ VGND VGND VPWR VPWR _0424_ sky130_fd_sc_hd__buf_2
X_1166_ _0199_ _0231_ _0262_ VGND VGND VPWR VPWR _0272_ sky130_fd_sc_hd__nand3b_1
X_1235_ net12 net44 VGND VGND VPWR VPWR _0355_ sky130_fd_sc_hd__xor2_1
X_2284_ net28 _0254_ VGND VGND VPWR VPWR _0255_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_19_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_82 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1999_ _0448_ _1096_ _1102_ VGND VGND VPWR VPWR _1103_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_30_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_8_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1922_ _1027_ _1026_ VGND VGND VPWR VPWR _1028_ sky130_fd_sc_hd__nor2_4
X_1853_ _0742_ _0726_ VGND VGND VPWR VPWR _0962_ sky130_fd_sc_hd__or2_1
X_1784_ _0891_ _0895_ VGND VGND VPWR VPWR _0896_ sky130_fd_sc_hd__nor2_1
XFILLER_0_12_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1149_ _0072_ _0082_ VGND VGND VPWR VPWR _0093_ sky130_fd_sc_hd__nand2_1
XFILLER_0_1_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2198_ _0116_ _0139_ _0163_ VGND VGND VPWR VPWR _0164_ sky130_fd_sc_hd__a21bo_1
X_2267_ _0219_ net106 _0235_ VGND VGND VPWR VPWR _0237_ sky130_fd_sc_hd__or3_1
X_1218_ _0322_ _0336_ _0337_ VGND VGND VPWR VPWR _0338_ sky130_fd_sc_hd__a21o_1
XFILLER_0_35_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_30_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_53_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2052_ _0589_ _0593_ VGND VGND VPWR VPWR _0011_ sky130_fd_sc_hd__or2_1
X_2121_ net20 _0081_ VGND VGND VPWR VPWR _0083_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_16_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_16_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xrebuffer18 _1054_ VGND VGND VPWR VPWR net118 sky130_fd_sc_hd__clkbuf_1
X_1905_ _0993_ _0639_ _0515_ VGND VGND VPWR VPWR _1012_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_8_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_290 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1767_ _0146_ _0860_ _0878_ VGND VGND VPWR VPWR _0879_ sky130_fd_sc_hd__o21a_1
X_1698_ _0448_ _0451_ _0652_ VGND VGND VPWR VPWR _0812_ sky130_fd_sc_hd__o21a_1
X_1836_ net6 net38 _0945_ VGND VGND VPWR VPWR _0946_ sky130_fd_sc_hd__o21a_1
XFILLER_0_4_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_4_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_12_121 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_12_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput76 net76 VGND VGND VPWR VPWR data_out[16] sky130_fd_sc_hd__clkbuf_4
Xoutput87 net87 VGND VGND VPWR VPWR data_out[26] sky130_fd_sc_hd__clkbuf_4
Xoutput98 net98 VGND VGND VPWR VPWR data_out[7] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_53_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_26_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1552_ net27 _0669_ VGND VGND VPWR VPWR _0670_ sky130_fd_sc_hd__xor2_2
X_1621_ _0735_ _0737_ VGND VGND VPWR VPWR _0738_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_1_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1483_ _0595_ _0601_ _0560_ VGND VGND VPWR VPWR _0602_ sky130_fd_sc_hd__mux2_1
XFILLER_0_27_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2104_ net17 _0028_ _0044_ net18 VGND VGND VPWR VPWR _0065_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_49_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_49_305 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2035_ _1136_ _1097_ _1039_ _0996_ _0495_ _0560_ VGND VGND VPWR VPWR _1137_ sky130_fd_sc_hd__mux4_1
XFILLER_0_57_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1819_ _0921_ _0926_ VGND VGND VPWR VPWR _0929_ sky130_fd_sc_hd__nand2_1
XFILLER_0_4_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xrebuffer9 net125 VGND VGND VPWR VPWR net109 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_64_16 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_54_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1604_ _0461_ _0717_ _0718_ _0493_ _0720_ VGND VGND VPWR VPWR _0721_ sky130_fd_sc_hd__a221oi_2
X_1535_ net37 net48 _0652_ VGND VGND VPWR VPWR _0654_ sky130_fd_sc_hd__and3_1
XFILLER_0_1_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1397_ net15 _0442_ _0252_ VGND VGND VPWR VPWR _0517_ sky130_fd_sc_hd__a21boi_1
X_1466_ _0583_ _0584_ _0504_ VGND VGND VPWR VPWR _0585_ sky130_fd_sc_hd__mux2_1
XFILLER_0_64_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2018_ _0770_ _0796_ _0359_ VGND VGND VPWR VPWR _1121_ sky130_fd_sc_hd__mux2_1
XFILLER_0_60_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_60_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_45_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_50_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_36_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_193 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1320_ net66 net65 net61 net60 VGND VGND VPWR VPWR _0440_ sky130_fd_sc_hd__or4_2
X_1182_ _0299_ _0301_ VGND VGND VPWR VPWR _0302_ sky130_fd_sc_hd__nand2_1
X_1251_ net56 VGND VGND VPWR VPWR _0371_ sky130_fd_sc_hd__inv_2
XFILLER_0_24_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_42_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_42_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_27_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_49_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1518_ _0553_ _0636_ _0551_ VGND VGND VPWR VPWR _0637_ sky130_fd_sc_hd__o21a_1
X_1449_ _0553_ _0568_ VGND VGND VPWR VPWR _0569_ sky130_fd_sc_hd__or2_1
XFILLER_0_10_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_33_344 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_61_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_28_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_24_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_24_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_249 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_3_205 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1303_ _0409_ _0422_ VGND VGND VPWR VPWR _0423_ sky130_fd_sc_hd__nor2_1
X_2283_ net60 _0253_ VGND VGND VPWR VPWR _0254_ sky130_fd_sc_hd__xnor2_1
X_1165_ _0252_ net5 VGND VGND VPWR VPWR _0262_ sky130_fd_sc_hd__or2b_1
XFILLER_0_35_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1234_ _0347_ _0350_ _0351_ _0353_ VGND VGND VPWR VPWR _0354_ sky130_fd_sc_hd__nand4_1
XFILLER_0_59_263 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_51_94 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_42_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1998_ _0884_ _1099_ _1100_ _1101_ _0898_ VGND VGND VPWR VPWR _1102_ sky130_fd_sc_hd__a2111o_1
XFILLER_0_30_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1852_ _0713_ _0717_ _0783_ VGND VGND VPWR VPWR _0961_ sky130_fd_sc_hd__mux2_1
X_1921_ net123 _1025_ net10 VGND VGND VPWR VPWR _1027_ sky130_fd_sc_hd__a21oi_1
X_1783_ _0290_ _0545_ _0503_ _0894_ VGND VGND VPWR VPWR _0895_ sky130_fd_sc_hd__o31a_1
XFILLER_0_24_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_21_75 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2266_ _0219_ _0223_ _0235_ VGND VGND VPWR VPWR _0236_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_47_211 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1148_ net36 net68 VGND VGND VPWR VPWR _0082_ sky130_fd_sc_hd__nand2_1
X_2197_ _0111_ _0136_ _0137_ VGND VGND VPWR VPWR _0163_ sky130_fd_sc_hd__o21ai_1
X_1217_ net11 net43 VGND VGND VPWR VPWR _0337_ sky130_fd_sc_hd__and2b_1
XFILLER_0_7_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2120_ net52 _0080_ VGND VGND VPWR VPWR _0081_ sky130_fd_sc_hd__xnor2_2
X_2051_ _0290_ _0293_ VGND VGND VPWR VPWR _0010_ sky130_fd_sc_hd__nor2_2
Xrebuffer19 _0933_ VGND VGND VPWR VPWR net119 sky130_fd_sc_hd__buf_1
XFILLER_0_16_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1904_ _0512_ _1010_ VGND VGND VPWR VPWR _1011_ sky130_fd_sc_hd__or2_1
X_1835_ net6 net38 _0888_ _0429_ VGND VGND VPWR VPWR _0945_ sky130_fd_sc_hd__a31o_1
XFILLER_0_4_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_8_105 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1697_ _0811_ VGND VGND VPWR VPWR net96 sky130_fd_sc_hd__clkbuf_1
X_1766_ net33 _0813_ _0860_ _0146_ VGND VGND VPWR VPWR _0878_ sky130_fd_sc_hd__a22o_1
XFILLER_0_4_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_12_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2249_ net57 _0217_ VGND VGND VPWR VPWR _0218_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_35_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_7_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput99 net99 VGND VGND VPWR VPWR data_out[8] sky130_fd_sc_hd__clkbuf_4
Xoutput88 net88 VGND VGND VPWR VPWR data_out[27] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_9_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput77 net77 VGND VGND VPWR VPWR data_out[17] sky130_fd_sc_hd__clkbuf_4
X_1482_ _0597_ _0600_ _0504_ VGND VGND VPWR VPWR _0601_ sky130_fd_sc_hd__mux2_1
X_1620_ _0670_ _0671_ _0736_ VGND VGND VPWR VPWR _0737_ sky130_fd_sc_hd__a21o_1
X_1551_ _0666_ _0668_ VGND VGND VPWR VPWR _0669_ sky130_fd_sc_hd__or2_1
XFILLER_0_27_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2103_ net18 _0044_ VGND VGND VPWR VPWR _0064_ sky130_fd_sc_hd__nor2_1
X_2034_ _0516_ _0520_ VGND VGND VPWR VPWR _1136_ sky130_fd_sc_hd__or2_1
XFILLER_0_57_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_49_317 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_43_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1818_ _0908_ _0920_ _0928_ _0572_ VGND VGND VPWR VPWR net100 sky130_fd_sc_hd__o22a_1
XFILLER_0_25_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_40_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1749_ net33 _0813_ VGND VGND VPWR VPWR _0862_ sky130_fd_sc_hd__nand2_1
XFILLER_0_0_380 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_48_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_58_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_13_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_7 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1465_ _0535_ _0531_ _0425_ VGND VGND VPWR VPWR _0584_ sky130_fd_sc_hd__mux2_1
X_1603_ _0626_ _0625_ _0719_ _0501_ VGND VGND VPWR VPWR _0720_ sky130_fd_sc_hd__o211a_1
X_1534_ net37 _0652_ _0178_ VGND VGND VPWR VPWR _0653_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_1_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1396_ net14 net111 _0471_ VGND VGND VPWR VPWR _0516_ sky130_fd_sc_hd__a21oi_1
X_2017_ _1119_ VGND VGND VPWR VPWR _1120_ sky130_fd_sc_hd__buf_2
XFILLER_0_64_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_299 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_60_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_60_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_60_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_331 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1250_ net29 VGND VGND VPWR VPWR _0370_ sky130_fd_sc_hd__clkinv_4
X_1181_ net32 _0300_ VGND VGND VPWR VPWR _0301_ sky130_fd_sc_hd__nand2_1
XFILLER_0_24_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_42_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_40_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1517_ _0511_ _0604_ _0635_ _0566_ VGND VGND VPWR VPWR _0636_ sky130_fd_sc_hd__o2bb2a_1
X_1448_ _0554_ _0556_ _0563_ _0564_ _0567_ VGND VGND VPWR VPWR _0568_ sky130_fd_sc_hd__o41a_1
XFILLER_0_4_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_4_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_10_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1379_ _0498_ net16 _0462_ VGND VGND VPWR VPWR _0499_ sky130_fd_sc_hd__nand3_2
XFILLER_0_45_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_60_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_33_356 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_28_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_24_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_3_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_66 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_10_88 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1302_ _0421_ VGND VGND VPWR VPWR _0422_ sky130_fd_sc_hd__clkbuf_4
X_2282_ _0432_ _0159_ _0042_ VGND VGND VPWR VPWR _0253_ sky130_fd_sc_hd__o21ai_1
X_1233_ _0352_ net58 VGND VGND VPWR VPWR _0353_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_19_86 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1164_ _0241_ VGND VGND VPWR VPWR _0252_ sky130_fd_sc_hd__buf_2
XFILLER_0_59_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1997_ _0446_ VGND VGND VPWR VPWR _1101_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_30_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_56_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1851_ _0952_ _0934_ _0958_ VGND VGND VPWR VPWR _0960_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_8_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1920_ net10 _1024_ _1025_ VGND VGND VPWR VPWR _1026_ sky130_fd_sc_hd__and3_1
X_1782_ _0459_ _0893_ VGND VGND VPWR VPWR _0894_ sky130_fd_sc_hd__or2_1
XFILLER_0_24_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2196_ net23 _0161_ VGND VGND VPWR VPWR _0162_ sky130_fd_sc_hd__xnor2_1
X_2265_ _0352_ _0234_ VGND VGND VPWR VPWR _0235_ sky130_fd_sc_hd__xor2_1
X_1216_ _0326_ _0334_ _0335_ VGND VGND VPWR VPWR _0336_ sky130_fd_sc_hd__a21o_1
XFILLER_0_62_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1147_ net36 net68 VGND VGND VPWR VPWR _0072_ sky130_fd_sc_hd__or2_1
XFILLER_0_47_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_61_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_21_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2050_ _0356_ _0008_ _1090_ VGND VGND VPWR VPWR _0009_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_16_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_226 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_44_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1903_ _0905_ _0782_ _1009_ VGND VGND VPWR VPWR _1010_ sky130_fd_sc_hd__o21ai_1
X_1834_ _0699_ _0939_ _0943_ _0457_ VGND VGND VPWR VPWR _0944_ sky130_fd_sc_hd__o211a_1
XFILLER_0_32_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1765_ _0814_ _0861_ _0752_ _0753_ VGND VGND VPWR VPWR _0877_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_4_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_4_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1696_ _0791_ _0798_ _0810_ VGND VGND VPWR VPWR _0811_ sky130_fd_sc_hd__or3_1
XFILLER_0_4_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2179_ net22 net54 _0888_ _0143_ VGND VGND VPWR VPWR _0144_ sky130_fd_sc_hd__a31o_1
X_2248_ _0216_ _0159_ _0042_ VGND VGND VPWR VPWR _0217_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_35_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput78 net78 VGND VGND VPWR VPWR data_out[18] sky130_fd_sc_hd__clkbuf_4
Xoutput89 net89 VGND VGND VPWR VPWR data_out[28] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_58_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1481_ _0598_ _0599_ VGND VGND VPWR VPWR _0600_ sky130_fd_sc_hd__or2_1
X_1550_ _0502_ _0667_ net59 VGND VGND VPWR VPWR _0668_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_1_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2033_ net14 net46 _0865_ _1134_ VGND VGND VPWR VPWR _1135_ sky130_fd_sc_hd__o22a_1
XTAP_159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2102_ _0382_ _0062_ VGND VGND VPWR VPWR _0063_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_57_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_49_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1817_ _0921_ _0927_ VGND VGND VPWR VPWR _0928_ sky130_fd_sc_hd__xor2_1
X_1748_ _0146_ _0860_ VGND VGND VPWR VPWR _0861_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_25_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_4_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_17_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1679_ _0793_ _0646_ _0480_ VGND VGND VPWR VPWR _0794_ sky130_fd_sc_hd__mux2_1
XFILLER_0_40_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_39_340 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_54_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1602_ _0496_ _0631_ _0632_ VGND VGND VPWR VPWR _0719_ sky130_fd_sc_hd__or3_1
X_1464_ _0532_ _0581_ _0582_ VGND VGND VPWR VPWR _0583_ sky130_fd_sc_hd__mux2_1
XFILLER_0_38_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1533_ _0651_ VGND VGND VPWR VPWR _0652_ sky130_fd_sc_hd__buf_6
X_1395_ _0514_ VGND VGND VPWR VPWR _0515_ sky130_fd_sc_hd__buf_2
XFILLER_0_22_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2016_ _0455_ _0448_ VGND VGND VPWR VPWR _1119_ sky130_fd_sc_hd__or2_1
XFILLER_0_64_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_36_343 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1180_ net64 VGND VGND VPWR VPWR _0300_ sky130_fd_sc_hd__buf_4
XFILLER_0_54_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_6_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1516_ _0555_ _0619_ _0627_ _0493_ _0634_ VGND VGND VPWR VPWR _0635_ sky130_fd_sc_hd__a221oi_2
XFILLER_0_42_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1378_ _0252_ VGND VGND VPWR VPWR _0498_ sky130_fd_sc_hd__clkbuf_4
X_1447_ _0483_ _0494_ _0510_ _0566_ VGND VGND VPWR VPWR _0567_ sky130_fd_sc_hd__a31o_1
XFILLER_0_4_97 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_4_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_60_165 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_60_121 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_33_368 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_5_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_18_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_18_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_51_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1232_ net26 VGND VGND VPWR VPWR _0352_ sky130_fd_sc_hd__buf_4
X_1301_ _0398_ _0406_ net3 net4 VGND VGND VPWR VPWR _0421_ sky130_fd_sc_hd__or4b_2
XFILLER_0_19_98 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2281_ _0251_ VGND VGND VPWR VPWR net90 sky130_fd_sc_hd__clkbuf_1
X_1163_ net37 VGND VGND VPWR VPWR _0241_ sky130_fd_sc_hd__buf_2
XFILLER_0_59_243 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_47_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_9 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_51_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1996_ _0444_ _0451_ _0512_ VGND VGND VPWR VPWR _1100_ sky130_fd_sc_hd__o21a_1
XFILLER_0_15_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_305 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_21_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_29_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1781_ _0892_ _0830_ _0773_ _0690_ _0178_ _0480_ VGND VGND VPWR VPWR _0893_ sky130_fd_sc_hd__mux4_1
X_1850_ _0952_ _0934_ _0958_ VGND VGND VPWR VPWR _0959_ sky130_fd_sc_hd__and3_1
XFILLER_0_21_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2195_ net55 _0160_ VGND VGND VPWR VPWR _0161_ sky130_fd_sc_hd__xnor2_1
X_2264_ net58 _0233_ VGND VGND VPWR VPWR _0234_ sky130_fd_sc_hd__xnor2_4
X_1215_ net10 net42 VGND VGND VPWR VPWR _0335_ sky130_fd_sc_hd__and2b_1
X_1146_ net6 net38 VGND VGND VPWR VPWR _0061_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_15_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1979_ _1028_ _1031_ net117 _1082_ _1053_ VGND VGND VPWR VPWR _1083_ sky130_fd_sc_hd__a32oi_2
XFILLER_0_11_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_38_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_249 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_38_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1902_ _0547_ _0787_ VGND VGND VPWR VPWR _1009_ sky130_fd_sc_hd__or2_1
XFILLER_0_29_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1833_ _0514_ _0942_ VGND VGND VPWR VPWR _0943_ sky130_fd_sc_hd__nand2_1
XFILLER_0_32_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1764_ _0874_ _0875_ VGND VGND VPWR VPWR _0876_ sky130_fd_sc_hd__nand2_1
XFILLER_0_4_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1695_ _0458_ _0799_ _0802_ _0664_ _0809_ VGND VGND VPWR VPWR _0810_ sky130_fd_sc_hd__a32o_1
XFILLER_0_25_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2247_ net56 net55 VGND VGND VPWR VPWR _0216_ sky130_fd_sc_hd__or2_1
X_2178_ net22 net54 _0422_ VGND VGND VPWR VPWR _0143_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_7_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput79 net79 VGND VGND VPWR VPWR data_out[19] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_1_305 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1480_ net19 _0443_ _0498_ VGND VGND VPWR VPWR _0599_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_1_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2032_ net14 net46 _0428_ _1133_ VGND VGND VPWR VPWR _1134_ sky130_fd_sc_hd__a31o_1
X_2101_ net51 _0060_ VGND VGND VPWR VPWR _0062_ sky130_fd_sc_hd__xor2_2
XFILLER_0_11_9 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_57_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1678_ _0739_ _0792_ _0188_ VGND VGND VPWR VPWR _0793_ sky130_fd_sc_hd__mux2_1
X_1747_ net66 _0859_ VGND VGND VPWR VPWR _0860_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_25_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1816_ _0925_ _0926_ VGND VGND VPWR VPWR _0927_ sky130_fd_sc_hd__nand2_1
XFILLER_0_7_31 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_4_165 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_4_121 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_7_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_311 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_16_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_263 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_31_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_39_352 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_54_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1601_ _0610_ _0622_ _0626_ VGND VGND VPWR VPWR _0718_ sky130_fd_sc_hd__mux2_1
X_1532_ net2 net4 net3 net1 VGND VGND VPWR VPWR _0651_ sky130_fd_sc_hd__or4b_4
XFILLER_0_1_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1463_ _0471_ VGND VGND VPWR VPWR _0582_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_38_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1394_ _0511_ VGND VGND VPWR VPWR _0514_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_54_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2015_ _0550_ _0448_ VGND VGND VPWR VPWR _1118_ sky130_fd_sc_hd__or2_2
XTAP_491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_19 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_36_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_36_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_27_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_216 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1515_ _0497_ _0629_ _0630_ _0633_ _0501_ VGND VGND VPWR VPWR _0634_ sky130_fd_sc_hd__o311a_1
XFILLER_0_40_98 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_10_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1377_ _0496_ VGND VGND VPWR VPWR _0497_ sky130_fd_sc_hd__buf_4
X_1446_ _0565_ VGND VGND VPWR VPWR _0566_ sky130_fd_sc_hd__buf_2
XFILLER_0_4_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_18_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_60_177 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_60_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_18_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_41_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_51_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1162_ _0209_ _0220_ VGND VGND VPWR VPWR _0231_ sky130_fd_sc_hd__nand2_1
XFILLER_0_35_21 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1300_ _0416_ _0417_ _0419_ _0406_ VGND VGND VPWR VPWR _0420_ sky130_fd_sc_hd__a22o_1
X_1231_ net28 net60 VGND VGND VPWR VPWR _0351_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_19_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_66 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2280_ _1089_ _0238_ _0246_ _0250_ VGND VGND VPWR VPWR _0251_ sky130_fd_sc_hd__or4b_4
XFILLER_0_59_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1995_ _0893_ _1098_ _0905_ VGND VGND VPWR VPWR _1099_ sky130_fd_sc_hd__mux2_1
XFILLER_0_27_196 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_55_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1429_ _0515_ _0548_ VGND VGND VPWR VPWR _0549_ sky130_fd_sc_hd__nand2_1
XFILLER_0_23_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_317 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1780_ _0466_ _0485_ VGND VGND VPWR VPWR _0892_ sky130_fd_sc_hd__or2_1
XFILLER_0_24_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_9 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_46_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1145_ _0030_ _0041_ VGND VGND VPWR VPWR _0051_ sky130_fd_sc_hd__nand2_1
XFILLER_0_1_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2194_ _0042_ _0159_ VGND VGND VPWR VPWR _0160_ sky130_fd_sc_hd__nand2_1
X_2263_ net57 _0216_ _0159_ _0042_ VGND VGND VPWR VPWR _0233_ sky130_fd_sc_hd__o31a_2
X_1214_ _0332_ net40 _0325_ _0333_ VGND VGND VPWR VPWR _0334_ sky130_fd_sc_hd__a31o_1
XFILLER_0_62_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_62_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_47_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_30_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_144 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1978_ net107 _1052_ VGND VGND VPWR VPWR _1082_ sky130_fd_sc_hd__or2_1
XFILLER_0_11_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_61_261 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_38_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1832_ _0460_ _0701_ VGND VGND VPWR VPWR _0942_ sky130_fd_sc_hd__or2_1
XFILLER_0_29_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1901_ net115 _1007_ VGND VGND VPWR VPWR _1008_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_40_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1694_ _0807_ _0808_ VGND VGND VPWR VPWR _0809_ sky130_fd_sc_hd__xor2_2
X_1763_ net35 _0873_ VGND VGND VPWR VPWR _0875_ sky130_fd_sc_hd__or2_1
X_2246_ _0163_ _0211_ _0214_ VGND VGND VPWR VPWR _0215_ sky130_fd_sc_hd__o21a_1
X_2315_ _0572_ _0275_ _0276_ _0277_ _0287_ VGND VGND VPWR VPWR net93 sky130_fd_sc_hd__o32a_1
X_2177_ _0111_ _0116_ _0139_ _0141_ VGND VGND VPWR VPWR _0142_ sky130_fd_sc_hd__o31a_1
XFILLER_0_18_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput69 net69 VGND VGND VPWR VPWR data_out[0] sky130_fd_sc_hd__buf_2
XFILLER_0_3_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_22_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_317 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2100_ net50 net49 _0439_ net127 _0922_ VGND VGND VPWR VPWR _0060_ sky130_fd_sc_hd__o41a_1
X_2031_ net14 net46 _0744_ VGND VGND VPWR VPWR _1133_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_27_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1815_ net36 _0924_ VGND VGND VPWR VPWR _0926_ sky130_fd_sc_hd__nand2_1
XFILLER_0_4_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1677_ _0632_ _0623_ VGND VGND VPWR VPWR _0792_ sky130_fd_sc_hd__or2_1
XFILLER_0_40_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1746_ net65 _0447_ _0450_ _0652_ VGND VGND VPWR VPWR _0859_ sky130_fd_sc_hd__o31a_1
XFILLER_0_7_43 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_4_177 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2229_ _0515_ _0972_ _0196_ _1101_ VGND VGND VPWR VPWR _0197_ sky130_fd_sc_hd__a211o_1
XFILLER_0_63_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_323 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_31_297 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_31_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_54_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_39_364 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_13_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1462_ net25 _0506_ VGND VGND VPWR VPWR _0581_ sky130_fd_sc_hd__nand2_1
X_1600_ _0715_ _0716_ _0640_ VGND VGND VPWR VPWR _0717_ sky130_fd_sc_hd__mux2_1
X_1531_ _0647_ _0649_ VGND VGND VPWR VPWR _0650_ sky130_fd_sc_hd__nor2_1
XFILLER_0_1_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_22_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1393_ _0483_ _0494_ _0510_ _0512_ VGND VGND VPWR VPWR _0513_ sky130_fd_sc_hd__a31o_1
XFILLER_0_54_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2014_ _0884_ _1114_ _1115_ _1116_ _1101_ VGND VGND VPWR VPWR _1117_ sky130_fd_sc_hd__a311o_1
XFILLER_0_9_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_57_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1729_ _0459_ _0370_ VGND VGND VPWR VPWR _0842_ sky130_fd_sc_hd__nand2_2
XTAP_492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_183 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_51_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_36_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_39_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1514_ _0505_ _0631_ _0632_ VGND VGND VPWR VPWR _0633_ sky130_fd_sc_hd__or3_1
X_1445_ _0293_ _0564_ VGND VGND VPWR VPWR _0565_ sky130_fd_sc_hd__or2_1
XFILLER_0_10_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1376_ _0495_ VGND VGND VPWR VPWR _0496_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_4_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_60_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_261 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_18_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_36_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_36_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1161_ net16 _0178_ VGND VGND VPWR VPWR _0220_ sky130_fd_sc_hd__nand2_1
XFILLER_0_35_33 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1230_ _0348_ _0349_ VGND VGND VPWR VPWR _0350_ sky130_fd_sc_hd__or2_2
XFILLER_0_19_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1994_ _1097_ _1039_ _0996_ _0947_ _0497_ _0695_ VGND VGND VPWR VPWR _1098_ sky130_fd_sc_hd__mux4_1
XFILLER_0_42_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_15_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_48_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1428_ _0530_ _0546_ _0547_ VGND VGND VPWR VPWR _0548_ sky130_fd_sc_hd__mux2_1
X_1359_ net59 VGND VGND VPWR VPWR _0479_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_18_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_33_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2262_ _0232_ VGND VGND VPWR VPWR net89 sky130_fd_sc_hd__clkbuf_1
X_1213_ net9 net41 VGND VGND VPWR VPWR _0333_ sky130_fd_sc_hd__and2b_1
XFILLER_0_20_351 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_62_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1144_ net7 net39 VGND VGND VPWR VPWR _0041_ sky130_fd_sc_hd__nand2_1
X_2193_ _0433_ _0434_ _0439_ net127 VGND VGND VPWR VPWR _0159_ sky130_fd_sc_hd__or4_4
XFILLER_0_62_97 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_55_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_47_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1977_ _0881_ _0981_ _1079_ VGND VGND VPWR VPWR _1081_ sky130_fd_sc_hd__or3_4
XFILLER_0_30_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_61_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_12 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1831_ _0899_ _0940_ _0552_ VGND VGND VPWR VPWR _0941_ sky130_fd_sc_hd__o21a_1
X_1900_ _0979_ _0985_ _0977_ VGND VGND VPWR VPWR _1007_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_52_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1693_ _0752_ _0758_ VGND VGND VPWR VPWR _0808_ sky130_fd_sc_hd__nand2_1
X_1762_ net35 _0873_ VGND VGND VPWR VPWR _0874_ sky130_fd_sc_hd__nand2_1
XFILLER_0_57_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2245_ _0186_ _0213_ _0184_ VGND VGND VPWR VPWR _0214_ sky130_fd_sc_hd__a21oi_1
X_2176_ _0571_ _0140_ VGND VGND VPWR VPWR _0141_ sky130_fd_sc_hd__nor2_1
X_2314_ _0349_ _0888_ _0279_ _0286_ VGND VGND VPWR VPWR _0287_ sky130_fd_sc_hd__a211o_1
XPHY_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2030_ _0680_ _1118_ _1120_ _0702_ VGND VGND VPWR VPWR _1132_ sky130_fd_sc_hd__o22ai_1
XFILLER_0_43_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1745_ _0514_ _0848_ _0857_ _0458_ VGND VGND VPWR VPWR _0858_ sky130_fd_sc_hd__o211a_1
XFILLER_0_25_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1814_ net36 _0924_ VGND VGND VPWR VPWR _0925_ sky130_fd_sc_hd__or2_1
XFILLER_0_17_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_229 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_40_276 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1676_ _0553_ _0790_ _0551_ VGND VGND VPWR VPWR _0791_ sky130_fd_sc_hd__o21a_1
XFILLER_0_7_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2228_ _0724_ _0195_ VGND VGND VPWR VPWR _0196_ sky130_fd_sc_hd__nor2_1
X_2159_ net21 net53 _0428_ _0122_ VGND VGND VPWR VPWR _0123_ sky130_fd_sc_hd__a31o_1
XFILLER_0_30_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_63_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_48_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_31_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_376 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1461_ _0579_ VGND VGND VPWR VPWR _0580_ sky130_fd_sc_hd__inv_2
X_1530_ _0648_ VGND VGND VPWR VPWR _0649_ sky130_fd_sc_hd__buf_2
X_1392_ _0511_ VGND VGND VPWR VPWR _0512_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_54_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2013_ _0743_ _0553_ _0647_ _0448_ VGND VGND VPWR VPWR _1116_ sky130_fd_sc_hd__o31a_1
XFILLER_0_45_302 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_9_237 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1728_ _0459_ _0564_ VGND VGND VPWR VPWR _0841_ sky130_fd_sc_hd__or2_1
XTAP_493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1659_ _0774_ _0503_ _0479_ VGND VGND VPWR VPWR _0775_ sky130_fd_sc_hd__mux2_1
XFILLER_0_51_305 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_48_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_59_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1375_ _0178_ VGND VGND VPWR VPWR _0495_ sky130_fd_sc_hd__buf_4
X_1513_ net31 _0588_ _0471_ VGND VGND VPWR VPWR _0632_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_49_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1444_ _0370_ _0443_ VGND VGND VPWR VPWR _0564_ sky130_fd_sc_hd__nor2_4
XFILLER_0_18_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_198 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_41_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_5_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_19_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1160_ net16 _0178_ VGND VGND VPWR VPWR _0209_ sky130_fd_sc_hd__or2_1
XFILLER_0_35_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1993_ _0473_ _0519_ VGND VGND VPWR VPWR _1097_ sky130_fd_sc_hd__or2_1
XFILLER_0_51_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_2_265 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_2_221 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_15_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1358_ _0474_ _0477_ _0469_ VGND VGND VPWR VPWR _0478_ sky130_fd_sc_hd__mux2_1
X_1427_ _0460_ VGND VGND VPWR VPWR _0547_ sky130_fd_sc_hd__clkbuf_4
X_1289_ _0262_ _0408_ VGND VGND VPWR VPWR _0409_ sky130_fd_sc_hd__and2_1
XFILLER_0_33_179 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_56_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2192_ _0158_ VGND VGND VPWR VPWR net86 sky130_fd_sc_hd__clkbuf_1
X_2261_ _1089_ _0206_ _0210_ _0230_ VGND VGND VPWR VPWR _0232_ sky130_fd_sc_hd__or4b_1
X_1212_ net8 VGND VGND VPWR VPWR _0332_ sky130_fd_sc_hd__inv_2
XFILLER_0_20_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_62_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1143_ net7 net39 VGND VGND VPWR VPWR _0030_ sky130_fd_sc_hd__or2_1
XFILLER_0_1_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_55_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_7_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1976_ _1079_ _0984_ VGND VGND VPWR VPWR _1080_ sky130_fd_sc_hd__or2b_1
XFILLER_0_60_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_30_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1830_ _0724_ _0937_ _0939_ _0566_ VGND VGND VPWR VPWR _0940_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_32_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1761_ net67 _0872_ VGND VGND VPWR VPWR _0873_ sky130_fd_sc_hd__xnor2_1
X_1692_ _0805_ _0806_ VGND VGND VPWR VPWR _0807_ sky130_fd_sc_hd__and2_2
X_2313_ _0724_ _1065_ _0285_ _1101_ _0898_ VGND VGND VPWR VPWR _0286_ sky130_fd_sc_hd__a2111oi_4
X_2244_ net24 _0182_ VGND VGND VPWR VPWR _0213_ sky130_fd_sc_hd__or2_1
X_2175_ _0111_ _0116_ _0139_ VGND VGND VPWR VPWR _0140_ sky130_fd_sc_hd__o21a_1
X_1959_ _1063_ _0970_ _0545_ VGND VGND VPWR VPWR _1064_ sky130_fd_sc_hd__mux2_1
XFILLER_0_43_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1744_ _0514_ _0856_ VGND VGND VPWR VPWR _0857_ sky130_fd_sc_hd__nand2_1
X_1813_ net68 _0923_ VGND VGND VPWR VPWR _0924_ sky130_fd_sc_hd__xnor2_1
X_1675_ _0699_ _0786_ _0789_ _0566_ VGND VGND VPWR VPWR _0790_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_0_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2089_ _0598_ _0590_ VGND VGND VPWR VPWR _0049_ sky130_fd_sc_hd__or2_1
XFILLER_0_48_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2227_ _0501_ _0193_ _0194_ VGND VGND VPWR VPWR _0195_ sky130_fd_sc_hd__a21oi_1
X_2158_ net21 net53 _0421_ VGND VGND VPWR VPWR _0122_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_23_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_48_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_48_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_13_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_39_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1460_ _0576_ _0577_ _0578_ VGND VGND VPWR VPWR _0579_ sky130_fd_sc_hd__a21oi_1
X_1391_ _0293_ VGND VGND VPWR VPWR _0511_ sky130_fd_sc_hd__buf_2
XFILLER_0_54_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2012_ _0743_ _0914_ VGND VGND VPWR VPWR _1115_ sky130_fd_sc_hd__nand2_1
XFILLER_0_57_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_314 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_9_249 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_53_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1658_ _0690_ _0773_ _0188_ VGND VGND VPWR VPWR _0774_ sky130_fd_sc_hd__mux2_1
X_1727_ _0840_ VGND VGND VPWR VPWR net97 sky130_fd_sc_hd__clkbuf_1
XTAP_494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1589_ net59 _0564_ VGND VGND VPWR VPWR _0706_ sky130_fd_sc_hd__or2_1
XFILLER_0_48_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_51_317 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_8_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_27_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1512_ net30 _0588_ _0498_ VGND VGND VPWR VPWR _0631_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_49_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1374_ _0491_ _0493_ VGND VGND VPWR VPWR _0494_ sky130_fd_sc_hd__nand2_1
X_1443_ _0460_ _0562_ VGND VGND VPWR VPWR _0563_ sky130_fd_sc_hd__and2_1
XFILLER_0_41_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_122 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_36_100 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_51_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_350 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_10_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1992_ _0456_ _0548_ _1095_ VGND VGND VPWR VPWR _1096_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_42_158 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_42_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_2_277 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_2_233 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1357_ _0475_ _0476_ VGND VGND VPWR VPWR _0477_ sky130_fd_sc_hd__or2_1
X_1288_ net5 net37 VGND VGND VPWR VPWR _0408_ sky130_fd_sc_hd__or2b_1
X_1426_ _0537_ _0544_ _0545_ VGND VGND VPWR VPWR _0546_ sky130_fd_sc_hd__mux2_1
XFILLER_0_58_291 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_18_100 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_52_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_12_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1142_ net39 VGND VGND VPWR VPWR _0019_ sky130_fd_sc_hd__inv_2
X_2191_ _1090_ _0142_ _0145_ _0156_ VGND VGND VPWR VPWR _0158_ sky130_fd_sc_hd__or4_1
X_2260_ _0571_ _0223_ _0224_ _0229_ _0553_ VGND VGND VPWR VPWR _0230_ sky130_fd_sc_hd__o32a_1
X_1211_ _0319_ _0330_ VGND VGND VPWR VPWR _0331_ sky130_fd_sc_hd__and2b_1
XFILLER_0_62_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_62_209 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1975_ _1078_ _1006_ _1028_ _1054_ VGND VGND VPWR VPWR _1079_ sky130_fd_sc_hd__or4bb_4
X_1409_ _0525_ _0528_ _0188_ VGND VGND VPWR VPWR _0529_ sky130_fd_sc_hd__mux2_1
XFILLER_0_53_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_11_320 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_46_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_239 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_29_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1691_ net32 _0804_ VGND VGND VPWR VPWR _0806_ sky130_fd_sc_hd__or2_1
X_1760_ _0451_ _0871_ _0667_ VGND VGND VPWR VPWR _0872_ sky130_fd_sc_hd__o21a_1
XFILLER_0_57_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_57_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2312_ _0512_ _0284_ VGND VGND VPWR VPWR _0285_ sky130_fd_sc_hd__nor2_1
XFILLER_0_12_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2174_ _0138_ VGND VGND VPWR VPWR _0139_ sky130_fd_sc_hd__inv_2
X_2243_ _0104_ _0108_ _0138_ _0211_ _0115_ VGND VGND VPWR VPWR _0212_ sky130_fd_sc_hd__a2111o_1
XFILLER_0_28_283 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_7_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1958_ _1013_ _1062_ _0505_ VGND VGND VPWR VPWR _1063_ sky130_fd_sc_hd__mux2_1
X_1889_ _0996_ _0947_ _0892_ _0830_ _0178_ _0479_ VGND VGND VPWR VPWR _0997_ sky130_fd_sc_hd__mux4_1
XFILLER_0_43_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1674_ _0547_ _0787_ _0788_ VGND VGND VPWR VPWR _0789_ sky130_fd_sc_hd__a21oi_1
X_1743_ _0742_ _0855_ _0844_ VGND VGND VPWR VPWR _0856_ sky130_fd_sc_hd__a21oi_1
X_1812_ net67 _0451_ _0871_ _0922_ VGND VGND VPWR VPWR _0923_ sky130_fd_sc_hd__o31a_1
XFILLER_0_7_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2226_ _0547_ _0013_ _0089_ _0493_ VGND VGND VPWR VPWR _0194_ sky130_fd_sc_hd__a22o_1
XFILLER_0_48_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2157_ _0895_ _0120_ _0511_ VGND VGND VPWR VPWR _0121_ sky130_fd_sc_hd__and3b_1
X_2088_ _0045_ _0047_ VGND VGND VPWR VPWR _0048_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_63_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_48_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_33_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1390_ _0497_ _0499_ _0501_ _0503_ _0509_ VGND VGND VPWR VPWR _0510_ sky130_fd_sc_hd__o2111ai_4
X_2011_ _0743_ _1113_ VGND VGND VPWR VPWR _1114_ sky130_fd_sc_hd__or2_1
XFILLER_0_60_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_45_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1657_ _0488_ _0508_ VGND VGND VPWR VPWR _0773_ sky130_fd_sc_hd__or2_1
X_1588_ _0665_ _0672_ _0673_ _0705_ VGND VGND VPWR VPWR net91 sky130_fd_sc_hd__a31o_1
X_1726_ _0818_ _0829_ _0834_ _0839_ VGND VGND VPWR VPWR _0840_ sky130_fd_sc_hd__or4_1
XFILLER_0_13_212 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2209_ _1089_ _0166_ _0170_ _0175_ VGND VGND VPWR VPWR _0176_ sky130_fd_sc_hd__or4_1
XFILLER_0_48_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_63_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_42_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1511_ net16 _0506_ _0582_ VGND VGND VPWR VPWR _0630_ sky130_fd_sc_hd__a21oi_1
X_1442_ _0481_ _0559_ _0561_ VGND VGND VPWR VPWR _0562_ sky130_fd_sc_hd__a21o_1
X_1373_ _0492_ VGND VGND VPWR VPWR _0493_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_45_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1709_ _0783_ _0820_ _0822_ VGND VGND VPWR VPWR _0823_ sky130_fd_sc_hd__o21ai_1
XTAP_270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_51_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1991_ _0556_ _0563_ _0564_ _1088_ VGND VGND VPWR VPWR _1095_ sky130_fd_sc_hd__o31a_1
XFILLER_0_27_145 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_15_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1425_ _0481_ VGND VGND VPWR VPWR _0545_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_23_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_2_289 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_2_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1356_ net9 _0442_ _0252_ VGND VGND VPWR VPWR _0476_ sky130_fd_sc_hd__a21boi_1
X_1287_ _0135_ _0305_ VGND VGND VPWR VPWR _0407_ sky130_fd_sc_hd__nor2_1
XFILLER_0_18_112 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_41_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_24_126 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_21_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_20_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2190_ _0153_ _0155_ _0898_ VGND VGND VPWR VPWR _0156_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_1_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1210_ _0322_ _0325_ _0326_ _0329_ VGND VGND VPWR VPWR _0330_ sky130_fd_sc_hd__and4_1
XFILLER_0_55_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1974_ _0977_ _0978_ VGND VGND VPWR VPWR _1078_ sky130_fd_sc_hd__nand2_1
XFILLER_0_11_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_93 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_11_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1408_ _0526_ _0527_ VGND VGND VPWR VPWR _0528_ sky130_fd_sc_hd__or2_1
XFILLER_0_46_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1339_ net62 VGND VGND VPWR VPWR _0459_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_16_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1690_ net32 _0804_ VGND VGND VPWR VPWR _0805_ sky130_fd_sc_hd__nand2_1
XFILLER_0_4_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2311_ _0547_ _0091_ _0280_ _0493_ _0282_ VGND VGND VPWR VPWR _0284_ sky130_fd_sc_hd__a221o_1
X_2242_ _0162_ _0185_ VGND VGND VPWR VPWR _0211_ sky130_fd_sc_hd__nand2_1
X_2173_ _0136_ _0137_ VGND VGND VPWR VPWR _0138_ sky130_fd_sc_hd__or2b_1
X_1957_ _0612_ _0616_ VGND VGND VPWR VPWR _1062_ sky130_fd_sc_hd__or2_1
XFILLER_0_43_210 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_28_295 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1888_ _0475_ _0464_ VGND VGND VPWR VPWR _0996_ sky130_fd_sc_hd__or2_1
XFILLER_0_31_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_57_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1811_ _0652_ VGND VGND VPWR VPWR _0922_ sky130_fd_sc_hd__clkbuf_4
X_1673_ _0493_ _0611_ _0627_ _0501_ VGND VGND VPWR VPWR _0788_ sky130_fd_sc_hd__a22o_1
X_1742_ _0541_ _0730_ VGND VGND VPWR VPWR _0855_ sky130_fd_sc_hd__nor2_1
XFILLER_0_7_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_0_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2225_ _0497_ _0191_ _0192_ VGND VGND VPWR VPWR _0193_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_48_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2156_ _0300_ _0446_ VGND VGND VPWR VPWR _0120_ sky130_fd_sc_hd__nor2_1
X_2087_ _0029_ _0037_ _0046_ VGND VGND VPWR VPWR _0047_ sky130_fd_sc_hd__o21a_1
XFILLER_0_63_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_16_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_7 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_3_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_13_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_129 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_22_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2010_ _1112_ _1062_ _1013_ _0969_ _0496_ _0481_ VGND VGND VPWR VPWR _1113_ sky130_fd_sc_hd__mux4_1
XFILLER_0_53_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_45_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1725_ _0512_ _0827_ _0838_ _0458_ VGND VGND VPWR VPWR _0839_ sky130_fd_sc_hd__o211a_1
XFILLER_0_13_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1587_ _0689_ _0694_ _0698_ _0704_ VGND VGND VPWR VPWR _0705_ sky130_fd_sc_hd__or4_1
X_1656_ _0768_ _0771_ _0294_ VGND VGND VPWR VPWR _0772_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_0_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2208_ _0742_ _1137_ _0174_ VGND VGND VPWR VPWR _0175_ sky130_fd_sc_hd__a21oi_1
X_2139_ _0029_ _0063_ _0083_ VGND VGND VPWR VPWR _0101_ sky130_fd_sc_hd__nor3_1
XFILLER_0_63_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_48_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_121 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_8_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_35_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_27_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_50_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1510_ _0471_ _0628_ VGND VGND VPWR VPWR _0629_ sky130_fd_sc_hd__and2_1
XFILLER_0_49_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1441_ _0560_ _0537_ VGND VGND VPWR VPWR _0561_ sky130_fd_sc_hd__nor2_1
XFILLER_0_4_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_10_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1372_ _0290_ _0479_ VGND VGND VPWR VPWR _0492_ sky130_fd_sc_hd__and2_2
XFILLER_0_45_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1708_ _0603_ _0821_ VGND VGND VPWR VPWR _0822_ sky130_fd_sc_hd__nand2_1
XFILLER_0_33_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1639_ _0736_ _0733_ _0734_ VGND VGND VPWR VPWR _0755_ sky130_fd_sc_hd__o21ba_1
XTAP_260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_138 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_10_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_17_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1990_ _1090_ _1093_ VGND VGND VPWR VPWR _1094_ sky130_fd_sc_hd__or2_1
XFILLER_0_27_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_319 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_62_9 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1355_ net8 _0462_ _0424_ VGND VGND VPWR VPWR _0475_ sky130_fd_sc_hd__a21oi_1
X_1424_ _0540_ _0543_ _0496_ VGND VGND VPWR VPWR _0544_ sky130_fd_sc_hd__mux2_1
XFILLER_0_23_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1286_ net1 VGND VGND VPWR VPWR _0406_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_18_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_24_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_20_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_1_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_7_305 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_7_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1973_ _1075_ _1076_ VGND VGND VPWR VPWR _1077_ sky130_fd_sc_hd__nand2_1
XFILLER_0_23_182 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_23_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1407_ net18 net111 _0241_ VGND VGND VPWR VPWR _0527_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_39_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1338_ _0457_ VGND VGND VPWR VPWR _0458_ sky130_fd_sc_hd__clkbuf_4
X_1269_ net20 _0372_ _0346_ _0381_ _0388_ VGND VGND VPWR VPWR _0389_ sky130_fd_sc_hd__o221a_1
XFILLER_0_52_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2310_ _0497_ _0239_ _0281_ _0993_ VGND VGND VPWR VPWR _0282_ sky130_fd_sc_hd__a211oi_1
X_2172_ net22 _0134_ VGND VGND VPWR VPWR _0137_ sky130_fd_sc_hd__or2_1
X_2241_ net25 net57 _0865_ _0208_ VGND VGND VPWR VPWR _0210_ sky130_fd_sc_hd__o22a_1
XFILLER_0_20_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1887_ _0989_ _0994_ _0512_ VGND VGND VPWR VPWR _0995_ sky130_fd_sc_hd__mux2_1
X_1956_ _0512_ _1060_ VGND VGND VPWR VPWR _1061_ sky130_fd_sc_hd__or2_1
XFILLER_0_7_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_277 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_34_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_43_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1741_ _0649_ _0853_ VGND VGND VPWR VPWR _0854_ sky130_fd_sc_hd__nor2_1
X_1810_ _0874_ _0882_ VGND VGND VPWR VPWR _0921_ sky130_fd_sc_hd__and2_1
XFILLER_0_25_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1672_ _0618_ _0595_ _0640_ VGND VGND VPWR VPWR _0787_ sky130_fd_sc_hd__mux2_1
XFILLER_0_25_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2224_ _0497_ _0148_ VGND VGND VPWR VPWR _0192_ sky130_fd_sc_hd__nand2_1
X_2155_ _0550_ _0900_ _0118_ VGND VGND VPWR VPWR _0119_ sky130_fd_sc_hd__o21a_1
XFILLER_0_63_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2086_ net17 _0028_ VGND VGND VPWR VPWR _0046_ sky130_fd_sc_hd__nand2_1
XFILLER_0_31_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1939_ net10 net42 _0865_ _1044_ VGND VGND VPWR VPWR _1045_ sky130_fd_sc_hd__o22a_1
XFILLER_0_3_193 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_54_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_60_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_53_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1724_ _0512_ _0837_ VGND VGND VPWR VPWR _0838_ sky130_fd_sc_hd__nand2_1
XTAP_475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1586_ _0699_ _0687_ _0703_ _0457_ VGND VGND VPWR VPWR _0704_ sky130_fd_sc_hd__o211a_1
X_1655_ _0770_ _0744_ _0295_ VGND VGND VPWR VPWR _0771_ sky130_fd_sc_hd__mux2_1
XFILLER_0_0_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2207_ _0493_ _0171_ _0173_ _0501_ _0891_ VGND VGND VPWR VPWR _0174_ sky130_fd_sc_hd__a221o_1
XFILLER_0_44_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2138_ _0572_ _0086_ _0100_ VGND VGND VPWR VPWR net84 sky130_fd_sc_hd__o21ai_4
XFILLER_0_28_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2069_ net49 _0027_ VGND VGND VPWR VPWR _0028_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_21_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_63_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_63_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_48_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_40_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1371_ _0486_ _0490_ _0469_ VGND VGND VPWR VPWR _0491_ sky130_fd_sc_hd__mux2_1
X_1440_ _0479_ VGND VGND VPWR VPWR _0560_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_4_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_14_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_94 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_60_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1707_ _0678_ _0675_ _0560_ VGND VGND VPWR VPWR _0821_ sky130_fd_sc_hd__mux2_1
X_1638_ _0752_ _0753_ VGND VGND VPWR VPWR _0754_ sky130_fd_sc_hd__and2_1
X_1569_ _0460_ _0683_ _0684_ _0493_ _0686_ VGND VGND VPWR VPWR _0687_ sky130_fd_sc_hd__a221oi_2
XFILLER_0_39_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_180 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_24_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_17_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_19_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_51_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_27_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1354_ _0472_ _0473_ VGND VGND VPWR VPWR _0474_ sky130_fd_sc_hd__or2_1
X_1423_ _0426_ _0541_ _0542_ VGND VGND VPWR VPWR _0543_ sky130_fd_sc_hd__a21o_1
X_1285_ _0369_ _0397_ _0404_ VGND VGND VPWR VPWR _0405_ sky130_fd_sc_hd__and3_1
XFILLER_0_46_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_81 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_64_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_64_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_20_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_1_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_28_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_317 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1972_ net12 _1074_ VGND VGND VPWR VPWR _1076_ sky130_fd_sc_hd__or2_1
X_1406_ net17 net111 _0252_ VGND VGND VPWR VPWR _0526_ sky130_fd_sc_hd__a21oi_1
X_1337_ _0300_ _0456_ VGND VGND VPWR VPWR _0457_ sky130_fd_sc_hd__nor2_2
X_1268_ _0341_ _0342_ _0383_ _0387_ VGND VGND VPWR VPWR _0388_ sky130_fd_sc_hd__a22o_1
XFILLER_0_46_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1199_ net7 _0019_ _0135_ _0312_ _0318_ VGND VGND VPWR VPWR _0319_ sky130_fd_sc_hd__o221a_1
XFILLER_0_61_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_16_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_37_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_52_278 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_57_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2171_ net22 _0134_ VGND VGND VPWR VPWR _0136_ sky130_fd_sc_hd__and2_1
X_2240_ net25 net57 _0888_ _0207_ VGND VGND VPWR VPWR _0208_ sky130_fd_sc_hd__a31o_1
XFILLER_0_20_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1955_ _0905_ _0843_ _1059_ VGND VGND VPWR VPWR _1060_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_28_264 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_28_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1886_ _0993_ _0544_ VGND VGND VPWR VPWR _0994_ sky130_fd_sc_hd__or2_1
XFILLER_0_7_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_57_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_43_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1740_ _0852_ _0740_ _0545_ VGND VGND VPWR VPWR _0853_ sky130_fd_sc_hd__mux2_1
XFILLER_0_40_226 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_40_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1671_ _0603_ _0782_ _0785_ VGND VGND VPWR VPWR _0786_ sky130_fd_sc_hd__a21o_1
XFILLER_0_4_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2223_ _0426_ net23 _0506_ _0190_ VGND VGND VPWR VPWR _0191_ sky130_fd_sc_hd__a31o_1
X_2154_ _0743_ _0456_ _0546_ VGND VGND VPWR VPWR _0118_ sky130_fd_sc_hd__or3_1
X_2085_ _0384_ _0044_ VGND VGND VPWR VPWR _0045_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_17_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1938_ net10 net42 _0428_ _1043_ VGND VGND VPWR VPWR _1044_ sky130_fd_sc_hd__a31o_1
XFILLER_0_3_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1869_ net8 _0976_ VGND VGND VPWR VPWR _0977_ sky130_fd_sc_hd__nand2_1
XFILLER_0_39_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_226 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_38_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_57_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1723_ _0742_ _0835_ _0836_ VGND VGND VPWR VPWR _0837_ sky130_fd_sc_hd__a21oi_1
X_1654_ _0769_ VGND VGND VPWR VPWR _0770_ sky130_fd_sc_hd__buf_2
X_2206_ _0127_ _0172_ _0626_ VGND VGND VPWR VPWR _0173_ sky130_fd_sc_hd__mux2_1
XTAP_498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1585_ _0514_ _0702_ VGND VGND VPWR VPWR _0703_ sky130_fd_sc_hd__nand2_1
XFILLER_0_21_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2137_ _0845_ _1118_ _0096_ _0099_ VGND VGND VPWR VPWR _0100_ sky130_fd_sc_hd__o211a_1
X_2068_ _0439_ net127 _0922_ VGND VGND VPWR VPWR _0027_ sky130_fd_sc_hd__o21a_1
XFILLER_0_63_137 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_24_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_50_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_50_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_49_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_35_340 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1370_ _0488_ _0489_ VGND VGND VPWR VPWR _0490_ sky130_fd_sc_hd__or2_1
XFILLER_0_45_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_351 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_5_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1706_ _0545_ _0819_ _0707_ VGND VGND VPWR VPWR _0820_ sky130_fd_sc_hd__o21a_1
X_1637_ net31 _0750_ _0751_ VGND VGND VPWR VPWR _0753_ sky130_fd_sc_hd__or3_1
XFILLER_0_30_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1499_ _0614_ _0617_ _0469_ VGND VGND VPWR VPWR _0618_ sky130_fd_sc_hd__mux2_1
X_1568_ _0626_ _0490_ _0500_ _0685_ VGND VGND VPWR VPWR _0686_ sky130_fd_sc_hd__o211a_1
XTAP_240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_17_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_3_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_51_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_27_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1422_ net28 _0441_ _0241_ VGND VGND VPWR VPWR _0542_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_42_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1353_ net11 _0442_ _0241_ VGND VGND VPWR VPWR _0473_ sky130_fd_sc_hd__a21boi_1
X_1284_ _0398_ _0403_ _0350_ VGND VGND VPWR VPWR _0404_ sky130_fd_sc_hd__mux2_1
XFILLER_0_61_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_14_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_41_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_5_93 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_64_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_151 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_46_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1971_ net12 _1074_ VGND VGND VPWR VPWR _1075_ sky130_fd_sc_hd__nand2_1
XFILLER_0_15_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1405_ _0424_ _0523_ _0524_ VGND VGND VPWR VPWR _0525_ sky130_fd_sc_hd__a21o_1
Xinput1 control[0] VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__clkbuf_2
X_1336_ _0455_ VGND VGND VPWR VPWR _0456_ sky130_fd_sc_hd__clkbuf_4
X_1267_ _0385_ _0386_ _0345_ VGND VGND VPWR VPWR _0387_ sky130_fd_sc_hd__a21bo_1
X_1198_ _0051_ _0317_ VGND VGND VPWR VPWR _0318_ sky130_fd_sc_hd__nand2_1
XFILLER_0_52_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_61_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_25_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_57_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_20_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2170_ net54 _0133_ VGND VGND VPWR VPWR _0134_ sky130_fd_sc_hd__xnor2_1
X_1954_ _0461_ _0846_ VGND VGND VPWR VPWR _1059_ sky130_fd_sc_hd__or2_1
XFILLER_0_28_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1885_ _0992_ VGND VGND VPWR VPWR _0993_ sky130_fd_sc_hd__clkbuf_2
XFILLER_0_43_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_11_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2299_ _0254_ net28 VGND VGND VPWR VPWR _0270_ sky130_fd_sc_hd__or2b_1
X_1319_ _0437_ _0438_ VGND VGND VPWR VPWR _0439_ sky130_fd_sc_hd__or2_2
XPHY_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_57_305 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_43_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1670_ _0783_ _0784_ VGND VGND VPWR VPWR _0785_ sky130_fd_sc_hd__nor2_1
XFILLER_0_25_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2222_ _0426_ _0532_ VGND VGND VPWR VPWR _0190_ sky130_fd_sc_hd__nor2_1
XFILLER_0_0_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2084_ net50 _0043_ VGND VGND VPWR VPWR _0044_ sky130_fd_sc_hd__xnor2_2
X_2153_ _0115_ net102 _0108_ _0572_ VGND VGND VPWR VPWR _0117_ sky130_fd_sc_hd__a31o_1
XFILLER_0_17_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1937_ net10 net42 _0744_ VGND VGND VPWR VPWR _1043_ sky130_fd_sc_hd__a21oi_1
X_1799_ _0884_ _0906_ VGND VGND VPWR VPWR _0910_ sky130_fd_sc_hd__nand2_1
X_1868_ net40 net110 VGND VGND VPWR VPWR _0976_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_58_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_22_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_238 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_54_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1584_ _0679_ _0701_ _0555_ VGND VGND VPWR VPWR _0702_ sky130_fd_sc_hd__mux2_1
X_1722_ _0547_ _0821_ VGND VGND VPWR VPWR _0836_ sky130_fd_sc_hd__nor2_1
XTAP_400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1653_ _0416_ _0418_ VGND VGND VPWR VPWR _0769_ sky130_fd_sc_hd__or2_1
XFILLER_0_0_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_260 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2205_ _0531_ _0535_ _0425_ VGND VGND VPWR VPWR _0172_ sky130_fd_sc_hd__mux2_1
XTAP_499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_44_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2067_ _0547_ _0775_ _0024_ _0025_ _0699_ VGND VGND VPWR VPWR _0026_ sky130_fd_sc_hd__o32a_1
X_2136_ _0341_ _0098_ _1090_ VGND VGND VPWR VPWR _0099_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_63_149 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_56_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_44_341 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_29_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_54_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_40_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_50_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_50_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_50_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_35_352 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_4_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_14_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1705_ _0674_ VGND VGND VPWR VPWR _0819_ sky130_fd_sc_hd__inv_2
XFILLER_0_41_300 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_26_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1567_ _0496_ _0507_ _0508_ VGND VGND VPWR VPWR _0685_ sky130_fd_sc_hd__or3_1
X_1636_ _0750_ _0751_ net31 VGND VGND VPWR VPWR _0752_ sky130_fd_sc_hd__o21ai_2
XTAP_230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1498_ _0615_ _0616_ VGND VGND VPWR VPWR _0617_ sky130_fd_sc_hd__or2_1
X_2119_ _0079_ _0439_ net127 _0042_ VGND VGND VPWR VPWR _0080_ sky130_fd_sc_hd__o31a_1
XTAP_252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_17_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_35_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_127 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1421_ net29 _0506_ VGND VGND VPWR VPWR _0541_ sky130_fd_sc_hd__nand2_2
XFILLER_0_50_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1352_ net10 _0442_ _0471_ VGND VGND VPWR VPWR _0472_ sky130_fd_sc_hd__a21oi_1
X_1283_ _0351_ _0401_ _0402_ VGND VGND VPWR VPWR _0403_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_58_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_14_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1619_ _0666_ _0668_ net27 VGND VGND VPWR VPWR _0736_ sky130_fd_sc_hd__o21a_1
XFILLER_0_1_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_49_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_263 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_9_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_163 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_32_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1970_ net44 _1073_ VGND VGND VPWR VPWR _1074_ sky130_fd_sc_hd__xor2_1
XFILLER_0_11_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1404_ net19 _0442_ _0471_ VGND VGND VPWR VPWR _0524_ sky130_fd_sc_hd__a21oi_1
X_1335_ net3 _0416_ net4 VGND VGND VPWR VPWR _0455_ sky130_fd_sc_hd__or3b_1
Xinput2 control[1] VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_36_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1197_ _0061_ _0315_ _0316_ VGND VGND VPWR VPWR _0317_ sky130_fd_sc_hd__a21o_1
X_1266_ net17 _0344_ net49 VGND VGND VPWR VPWR _0386_ sky130_fd_sc_hd__or3b_1
XFILLER_0_61_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_52_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_299 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_57_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1884_ net62 _0479_ VGND VGND VPWR VPWR _0992_ sky130_fd_sc_hd__or2_1
XFILLER_0_43_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1953_ _0515_ _1057_ VGND VGND VPWR VPWR _1058_ sky130_fd_sc_hd__nand2_1
XFILLER_0_22_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_22_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_11_144 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2298_ _0664_ _0258_ _0263_ _0269_ _1090_ VGND VGND VPWR VPWR net92 sky130_fd_sc_hd__a2111o_1
X_1318_ net43 net42 net41 net40 VGND VGND VPWR VPWR _0438_ sky130_fd_sc_hd__or4_4
XPHY_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1249_ _0331_ _0338_ _0368_ VGND VGND VPWR VPWR _0369_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_34_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_171 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_19_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_317 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_25_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2221_ _0185_ _0187_ VGND VGND VPWR VPWR _0189_ sky130_fd_sc_hd__xnor2_1
X_2152_ net101 _0108_ _0115_ VGND VGND VPWR VPWR _0116_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_33_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2083_ net49 _0027_ _0042_ VGND VGND VPWR VPWR _0043_ sky130_fd_sc_hd__o21a_1
X_1936_ _0891_ _1041_ VGND VGND VPWR VPWR _1042_ sky130_fd_sc_hd__nor2_1
X_1867_ _0435_ _0450_ _0871_ _0652_ VGND VGND VPWR VPWR _0975_ sky130_fd_sc_hd__o31a_1
X_1798_ _0743_ _0641_ _0515_ VGND VGND VPWR VPWR _0909_ sky130_fd_sc_hd__o21ai_1
Xinput60 data_in2[30] VGND VGND VPWR VPWR net60 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_54_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_47_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_38_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_57_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1721_ _0695_ _0700_ VGND VGND VPWR VPWR _0835_ sky130_fd_sc_hd__nor2_1
XFILLER_0_13_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1583_ _0675_ _0700_ _0481_ VGND VGND VPWR VPWR _0701_ sky130_fd_sc_hd__mux2_1
XTAP_423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_177 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_21_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1652_ _0767_ VGND VGND VPWR VPWR _0768_ sky130_fd_sc_hd__clkbuf_4
XTAP_489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2204_ _0022_ _0069_ _0626_ VGND VGND VPWR VPWR _0171_ sky130_fd_sc_hd__mux2_1
XTAP_478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2135_ _0768_ _0097_ VGND VGND VPWR VPWR _0098_ sky130_fd_sc_hd__nand2_1
XFILLER_0_63_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2066_ _0550_ _0761_ _0778_ _0456_ _0024_ VGND VGND VPWR VPWR _0025_ sky130_fd_sc_hd__o221a_1
XFILLER_0_8_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_277 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1919_ net109 _1023_ net42 VGND VGND VPWR VPWR _1025_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_47_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_364 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_50_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_50_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_49_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_58_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_60_109 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_53_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_312 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1704_ _0814_ _0816_ _0817_ VGND VGND VPWR VPWR _0818_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_30_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_5_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1497_ net10 _0443_ _0424_ VGND VGND VPWR VPWR _0616_ sky130_fd_sc_hd__a21boi_1
X_1566_ _0468_ _0486_ _0504_ VGND VGND VPWR VPWR _0684_ sky130_fd_sc_hd__mux2_1
X_1635_ _0293_ _0451_ _0667_ VGND VGND VPWR VPWR _0751_ sky130_fd_sc_hd__and3_1
XTAP_220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2118_ net51 net50 net49 VGND VGND VPWR VPWR _0079_ sky130_fd_sc_hd__or3_1
X_2049_ _0768_ _0007_ VGND VGND VPWR VPWR _0008_ sky130_fd_sc_hd__nand2_1
XTAP_286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_27_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1351_ _0241_ VGND VGND VPWR VPWR _0471_ sky130_fd_sc_hd__buf_2
X_1420_ _0538_ _0539_ VGND VGND VPWR VPWR _0540_ sky130_fd_sc_hd__or2_1
XFILLER_0_50_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1282_ net28 net60 VGND VGND VPWR VPWR _0402_ sky130_fd_sc_hd__and2b_1
XFILLER_0_18_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1618_ _0733_ _0734_ VGND VGND VPWR VPWR _0735_ sky130_fd_sc_hd__nor2_1
XFILLER_0_1_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_14_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_1_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1549_ _0652_ VGND VGND VPWR VPWR _0667_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_49_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_289 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_64_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_17_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_175 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_20_315 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_46_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_55_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_11_21 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_11_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1403_ net20 _0442_ VGND VGND VPWR VPWR _0523_ sky130_fd_sc_hd__nand2_1
X_1334_ _0411_ _0415_ _0453_ VGND VGND VPWR VPWR _0454_ sky130_fd_sc_hd__a21o_1
X_1265_ _0384_ net50 VGND VGND VPWR VPWR _0385_ sky130_fd_sc_hd__nand2_1
Xinput3 control[2] VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__clkbuf_4
X_1196_ net6 net38 VGND VGND VPWR VPWR _0316_ sky130_fd_sc_hd__and2b_1
XFILLER_0_61_237 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_14_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_20_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1952_ _0541_ _0451_ VGND VGND VPWR VPWR _1057_ sky130_fd_sc_hd__or2_1
X_1883_ _0898_ _0990_ _0552_ VGND VGND VPWR VPWR _0991_ sky130_fd_sc_hd__o21a_1
XFILLER_0_22_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_22_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_11_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_2_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1248_ _0346_ _0367_ VGND VGND VPWR VPWR _0368_ sky130_fd_sc_hd__nor2_1
X_1317_ net47 net46 net45 net44 VGND VGND VPWR VPWR _0437_ sky130_fd_sc_hd__or4_1
X_2297_ _0899_ _0268_ VGND VGND VPWR VPWR _0269_ sky130_fd_sc_hd__nor2_1
XPHY_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_82 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1179_ net32 net64 VGND VGND VPWR VPWR _0299_ sky130_fd_sc_hd__or2_1
XFILLER_0_2_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_19_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_109 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_7_19 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_0_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2151_ _0113_ VGND VGND VPWR VPWR _0115_ sky130_fd_sc_hd__inv_2
X_2220_ _0162_ _0164_ _0186_ VGND VGND VPWR VPWR _0187_ sky130_fd_sc_hd__a21oi_1
X_2082_ _0922_ VGND VGND VPWR VPWR _0042_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_16_9 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1935_ _0831_ _1040_ _0783_ VGND VGND VPWR VPWR _1041_ sky130_fd_sc_hd__mux2_1
Xinput50 data_in2[21] VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__buf_4
XFILLER_0_31_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1797_ _0899_ _0907_ _0552_ VGND VGND VPWR VPWR _0908_ sky130_fd_sc_hd__o21a_1
X_1866_ _0572_ _0959_ _0960_ _0974_ VGND VGND VPWR VPWR net71 sky130_fd_sc_hd__o31ai_2
Xinput61 data_in2[31] VGND VGND VPWR VPWR net61 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_16_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_47_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_62_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_30_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_57_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1720_ _0649_ _0831_ _0833_ VGND VGND VPWR VPWR _0834_ sky130_fd_sc_hd__o21ai_1
X_1651_ _0398_ _0406_ _0418_ VGND VGND VPWR VPWR _0767_ sky130_fd_sc_hd__or3_2
X_1582_ _0496_ _0543_ VGND VGND VPWR VPWR _0700_ sky130_fd_sc_hd__or2_1
XTAP_457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_0_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2065_ _0997_ _0010_ _0023_ _0014_ _0446_ VGND VGND VPWR VPWR _0024_ sky130_fd_sc_hd__a221o_1
X_2203_ net23 net55 _0429_ _0169_ VGND VGND VPWR VPWR _0170_ sky130_fd_sc_hd__o22a_1
XFILLER_0_28_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2134_ _0770_ _0796_ _0342_ VGND VGND VPWR VPWR _0097_ sky130_fd_sc_hd__mux2_1
XFILLER_0_60_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_170 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_29_340 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_44_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1849_ _0956_ _0957_ VGND VGND VPWR VPWR _0958_ sky130_fd_sc_hd__nand2_1
XFILLER_0_8_289 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_12_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1918_ _0975_ _1023_ net42 VGND VGND VPWR VPWR _1024_ sky130_fd_sc_hd__or3b_4
XFILLER_0_5_9 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_35_376 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_62_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_324 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1634_ _0451_ _0667_ _0293_ VGND VGND VPWR VPWR _0750_ sky130_fd_sc_hd__a21oi_1
X_1703_ _0814_ _0816_ _0664_ VGND VGND VPWR VPWR _0817_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_30_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_5_237 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1565_ _0681_ _0682_ _0480_ VGND VGND VPWR VPWR _0683_ sky130_fd_sc_hd__mux2_1
X_1496_ net9 _0443_ _0582_ VGND VGND VPWR VPWR _0615_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_39_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2117_ _0665_ _0068_ _0078_ _1090_ VGND VGND VPWR VPWR net83 sky130_fd_sc_hd__a211o_1
XFILLER_0_12_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2048_ _0770_ _0796_ _0357_ VGND VGND VPWR VPWR _0007_ sky130_fd_sc_hd__mux2_1
XFILLER_0_29_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_17_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_55_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1350_ _0465_ _0468_ _0469_ VGND VGND VPWR VPWR _0470_ sky130_fd_sc_hd__mux2_1
XFILLER_0_31_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1281_ _0399_ net57 _0353_ _0400_ VGND VGND VPWR VPWR _0401_ sky130_fd_sc_hd__a31o_1
XFILLER_0_14_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1617_ _0731_ _0732_ net30 VGND VGND VPWR VPWR _0734_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_14_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1479_ net18 _0588_ _0582_ VGND VGND VPWR VPWR _0598_ sky130_fd_sc_hd__a21oi_1
X_1548_ net59 _0502_ _0652_ VGND VGND VPWR VPWR _0666_ sky130_fd_sc_hd__and3_1
XFILLER_0_37_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_32_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_327 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_62_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_11_33 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1402_ _0518_ _0521_ _0469_ VGND VGND VPWR VPWR _0522_ sky130_fd_sc_hd__mux2_1
XFILLER_0_11_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_36_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1333_ _0420_ _0423_ _0431_ _0452_ VGND VGND VPWR VPWR _0453_ sky130_fd_sc_hd__or4b_1
X_1264_ net18 VGND VGND VPWR VPWR _0384_ sky130_fd_sc_hd__inv_2
Xinput4 control[3] VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_36_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1195_ _0313_ net67 _0093_ _0314_ VGND VGND VPWR VPWR _0315_ sky130_fd_sc_hd__a31o_1
XFILLER_0_19_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_61_249 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_61_205 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_6_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_6_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_14_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_20_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1882_ _0724_ _0988_ _0989_ _0901_ VGND VGND VPWR VPWR _0990_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_3_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1951_ net118 _1055_ VGND VGND VPWR VPWR _1056_ sky130_fd_sc_hd__xor2_1
XFILLER_0_22_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_51_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_11_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2296_ _1034_ _0198_ _0267_ _1101_ VGND VGND VPWR VPWR _0268_ sky130_fd_sc_hd__o22a_1
XFILLER_0_2_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1316_ _0432_ _0433_ _0434_ net122 VGND VGND VPWR VPWR _0436_ sky130_fd_sc_hd__or4_4
X_1247_ _0354_ _0355_ _0361_ _0366_ VGND VGND VPWR VPWR _0367_ sky130_fd_sc_hd__or4_1
X_1178_ _0296_ _0297_ VGND VGND VPWR VPWR _0298_ sky130_fd_sc_hd__nand2_1
XFILLER_0_63_94 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_97 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2081_ _0040_ VGND VGND VPWR VPWR net81 sky130_fd_sc_hd__buf_1
X_2150_ _0111_ _0112_ VGND VGND VPWR VPWR _0113_ sky130_fd_sc_hd__nor2_1
XFILLER_0_56_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1934_ _1039_ _0996_ _0947_ _0892_ _0496_ _0640_ VGND VGND VPWR VPWR _1040_ sky130_fd_sc_hd__mux4_1
X_1796_ _0515_ _0904_ _0906_ _0901_ VGND VGND VPWR VPWR _0907_ sky130_fd_sc_hd__a22oi_1
X_1865_ _0898_ _0456_ _0963_ _0966_ _0973_ VGND VGND VPWR VPWR _0974_ sky130_fd_sc_hd__o311a_1
Xinput40 data_in2[12] VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__clkbuf_4
Xinput62 data_in2[3] VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__buf_4
Xinput51 data_in2[22] VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_58_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_39_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2279_ _0993_ _0639_ _1120_ _0249_ VGND VGND VPWR VPWR _0250_ sky130_fd_sc_hd__o31a_1
XFILLER_0_62_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_47_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_15_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1650_ _0300_ _0765_ _0551_ VGND VGND VPWR VPWR _0766_ sky130_fd_sc_hd__o21a_1
X_1581_ _0511_ VGND VGND VPWR VPWR _0699_ sky130_fd_sc_hd__buf_2
XTAP_469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2202_ net23 net55 _0427_ _0168_ VGND VGND VPWR VPWR _0169_ sky130_fd_sc_hd__a31o_1
XFILLER_0_28_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2064_ _0022_ _1136_ _1097_ _1039_ _0178_ _0479_ VGND VGND VPWR VPWR _0023_ sky130_fd_sc_hd__mux4_2
XFILLER_0_44_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2133_ _0087_ _0094_ _0095_ _0515_ _0898_ VGND VGND VPWR VPWR _0096_ sky130_fd_sc_hd__a221o_1
XFILLER_0_56_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_352 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1917_ net41 net40 _0652_ VGND VGND VPWR VPWR _1023_ sky130_fd_sc_hd__o21a_1
XFILLER_0_44_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1779_ _0449_ VGND VGND VPWR VPWR _0891_ sky130_fd_sc_hd__clkbuf_4
X_1848_ net7 _0954_ _0955_ VGND VGND VPWR VPWR _0957_ sky130_fd_sc_hd__nand3b_1
XFILLER_0_8_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_8_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_35_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_205 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_14_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1633_ _0749_ VGND VGND VPWR VPWR net94 sky130_fd_sc_hd__clkbuf_1
X_1564_ _0474_ _0521_ _0178_ VGND VGND VPWR VPWR _0682_ sky130_fd_sc_hd__mux2_1
X_1702_ _0752_ _0758_ _0805_ _0815_ VGND VGND VPWR VPWR _0816_ sky130_fd_sc_hd__a31o_1
XFILLER_0_26_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_5_249 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1495_ _0612_ _0613_ VGND VGND VPWR VPWR _0614_ sky130_fd_sc_hd__or2_1
XFILLER_0_55_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2047_ _0000_ _1130_ _0004_ _0572_ VGND VGND VPWR VPWR _0006_ sky130_fd_sc_hd__a31o_1
X_2116_ _0899_ _0074_ _0077_ VGND VGND VPWR VPWR _0078_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_44_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_29_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1280_ _0352_ net58 VGND VGND VPWR VPWR _0400_ sky130_fd_sc_hd__and2b_1
XFILLER_0_41_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1616_ net30 _0731_ _0732_ VGND VGND VPWR VPWR _0733_ sky130_fd_sc_hd__and3_1
XFILLER_0_5_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1547_ _0664_ VGND VGND VPWR VPWR _0665_ sky130_fd_sc_hd__buf_4
X_1478_ _0425_ _0534_ _0596_ VGND VGND VPWR VPWR _0597_ sky130_fd_sc_hd__a21o_1
XFILLER_0_64_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_339 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_13_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1401_ _0519_ _0520_ VGND VGND VPWR VPWR _0521_ sky130_fd_sc_hd__or2_1
Xinput5 data_in1[0] VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_36_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1332_ _0444_ _0449_ _0451_ VGND VGND VPWR VPWR _0452_ sky130_fd_sc_hd__or3_1
X_1194_ net36 net68 VGND VGND VPWR VPWR _0314_ sky130_fd_sc_hd__and2b_1
X_1263_ _0382_ net51 VGND VGND VPWR VPWR _0383_ sky130_fd_sc_hd__nand2_1
XFILLER_0_52_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_61_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_6_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_14_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1950_ _1028_ _1032_ net107 VGND VGND VPWR VPWR _1055_ sky130_fd_sc_hd__a21o_1
X_1881_ _0760_ _0762_ _0783_ VGND VGND VPWR VPWR _0989_ sky130_fd_sc_hd__mux2_1
XFILLER_0_22_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1315_ net39 net38 net68 net67 VGND VGND VPWR VPWR _0435_ sky130_fd_sc_hd__or4_4
X_2295_ _1041_ _0266_ _0884_ VGND VGND VPWR VPWR _0267_ sky130_fd_sc_hd__mux2_1
XFILLER_0_2_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1246_ _0362_ _0363_ _0364_ _0365_ VGND VGND VPWR VPWR _0366_ sky130_fd_sc_hd__nand4_1
X_1177_ net33 net65 VGND VGND VPWR VPWR _0297_ sky130_fd_sc_hd__nand2_1
XFILLER_0_59_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_48_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_17_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2080_ _1090_ _0021_ _0039_ VGND VGND VPWR VPWR _0040_ sky130_fd_sc_hd__or3_2
X_1933_ _0472_ _0476_ VGND VGND VPWR VPWR _1039_ sky130_fd_sc_hd__or2_1
XFILLER_0_16_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput30 data_in1[3] VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__buf_4
Xinput63 data_in2[4] VGND VGND VPWR VPWR net63 sky130_fd_sc_hd__buf_2
Xinput52 data_in2[23] VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__clkbuf_4
X_1795_ _0602_ _0619_ _0905_ VGND VGND VPWR VPWR _0906_ sky130_fd_sc_hd__mux2_1
X_1864_ _0030_ _0968_ _0972_ _0891_ VGND VGND VPWR VPWR _0973_ sky130_fd_sc_hd__o2bb2a_1
Xinput41 data_in2[13] VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__buf_2
XFILLER_0_24_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2278_ _0352_ net58 _0248_ VGND VGND VPWR VPWR _0249_ sky130_fd_sc_hd__o21ai_1
X_1229_ net29 net61 VGND VGND VPWR VPWR _0349_ sky130_fd_sc_hd__and2_1
XFILLER_0_62_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_62_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_62_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1580_ net27 _0695_ _0696_ _0697_ VGND VGND VPWR VPWR _0698_ sky130_fd_sc_hd__o22a_1
XTAP_459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2132_ _0742_ _1101_ _0853_ VGND VGND VPWR VPWR _0095_ sky130_fd_sc_hd__or3_1
X_2201_ net23 net55 _0421_ VGND VGND VPWR VPWR _0168_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_0_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2063_ _0526_ _0517_ VGND VGND VPWR VPWR _0022_ sky130_fd_sc_hd__or2_1
XFILLER_0_48_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_60_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_60_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_44_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_29_364 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1916_ _0665_ _1008_ _1019_ _1022_ VGND VGND VPWR VPWR net73 sky130_fd_sc_hd__a211o_1
X_1847_ _0954_ _0955_ net7 VGND VGND VPWR VPWR _0956_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_8_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1778_ _0125_ _0796_ _0889_ _0103_ VGND VGND VPWR VPWR _0890_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_8_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_12_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_312 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_62_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_62_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_53_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_172 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1701_ net32 _0804_ VGND VGND VPWR VPWR _0815_ sky130_fd_sc_hd__nor2_1
XFILLER_0_26_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_5_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1494_ net12 _0588_ _0424_ VGND VGND VPWR VPWR _0613_ sky130_fd_sc_hd__a21boi_1
X_1563_ _0477_ _0465_ _0188_ VGND VGND VPWR VPWR _0681_ sky130_fd_sc_hd__mux2_1
XFILLER_0_41_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1632_ _0723_ _0729_ _0748_ VGND VGND VPWR VPWR _0749_ sky130_fd_sc_hd__or3b_2
XFILLER_0_1_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2115_ net19 net51 _0076_ VGND VGND VPWR VPWR _0077_ sky130_fd_sc_hd__o21ai_1
XTAP_245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2046_ _0000_ _1130_ _0004_ VGND VGND VPWR VPWR _0005_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_44_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_2_209 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_58_267 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_41_21 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_41_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_164 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1477_ net20 _0506_ _0425_ VGND VGND VPWR VPWR _0596_ sky130_fd_sc_hd__a21oi_1
X_1615_ _0667_ _0730_ _0289_ VGND VGND VPWR VPWR _0732_ sky130_fd_sc_hd__a21o_1
XFILLER_0_5_21 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1546_ _0420_ VGND VGND VPWR VPWR _0664_ sky130_fd_sc_hd__clkbuf_4
X_2029_ _1128_ _1129_ VGND VGND VPWR VPWR _1131_ sky130_fd_sc_hd__nand2_1
XFILLER_0_32_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_23_134 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_11_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1400_ net13 _0442_ _0241_ VGND VGND VPWR VPWR _0520_ sky130_fd_sc_hd__a21boi_1
X_1331_ _0450_ VGND VGND VPWR VPWR _0451_ sky130_fd_sc_hd__clkbuf_4
Xinput6 data_in1[10] VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__buf_4
XFILLER_0_36_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1193_ net35 VGND VGND VPWR VPWR _0313_ sky130_fd_sc_hd__inv_2
X_1262_ net19 VGND VGND VPWR VPWR _0382_ sky130_fd_sc_hd__inv_2
XFILLER_0_52_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_6_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_6_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1529_ _0555_ _0449_ VGND VGND VPWR VPWR _0648_ sky130_fd_sc_hd__or2_1
XFILLER_0_60_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1880_ _0555_ _0759_ _0842_ VGND VGND VPWR VPWR _0988_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_36_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2294_ _0555_ _0070_ _0173_ _0493_ _0265_ VGND VGND VPWR VPWR _0266_ sky130_fd_sc_hd__a221o_1
XFILLER_0_47_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1314_ net52 net51 net50 net49 VGND VGND VPWR VPWR _0434_ sky130_fd_sc_hd__or4_4
XFILLER_0_63_30 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_59_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_2_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1245_ net22 net54 VGND VGND VPWR VPWR _0365_ sky130_fd_sc_hd__xnor2_1
X_1176_ net33 net65 VGND VGND VPWR VPWR _0296_ sky130_fd_sc_hd__or2_1
XFILLER_0_27_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_67 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xinput31 data_in1[4] VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_56_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_56_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1863_ _0741_ _0971_ _0905_ VGND VGND VPWR VPWR _0972_ sky130_fd_sc_hd__mux2_1
XFILLER_0_33_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1932_ _0899_ _1037_ _0552_ VGND VGND VPWR VPWR _1038_ sky130_fd_sc_hd__o21a_1
Xinput20 data_in1[23] VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__buf_4
Xinput42 data_in2[14] VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__clkbuf_4
Xinput53 data_in2[24] VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__buf_4
XFILLER_0_58_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1794_ _0783_ VGND VGND VPWR VPWR _0905_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_3_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput64 data_in2[5] VGND VGND VPWR VPWR net64 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_28_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2277_ _0352_ net58 _0428_ _0247_ _0429_ VGND VGND VPWR VPWR _0248_ sky130_fd_sc_hd__a311o_1
X_1228_ net29 net61 VGND VGND VPWR VPWR _0348_ sky130_fd_sc_hd__nor2_1
X_1159_ net27 net59 VGND VGND VPWR VPWR _0199_ sky130_fd_sc_hd__xor2_1
XFILLER_0_62_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2131_ _0742_ _1064_ _0092_ _1101_ VGND VGND VPWR VPWR _0094_ sky130_fd_sc_hd__a211o_1
XTAP_416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2200_ _0942_ _1120_ VGND VGND VPWR VPWR _0166_ sky130_fd_sc_hd__nor2_1
X_2062_ _0768_ _0020_ _0339_ VGND VGND VPWR VPWR _0021_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_44_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_9 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_60_97 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_60_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_29_376 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1915_ _0899_ _1021_ _0552_ VGND VGND VPWR VPWR _1022_ sky130_fd_sc_hd__o21a_1
X_1777_ net35 net67 _0888_ _0429_ VGND VGND VPWR VPWR _0889_ sky130_fd_sc_hd__a31o_1
X_1846_ _0667_ _0953_ net39 VGND VGND VPWR VPWR _0955_ sky130_fd_sc_hd__a21o_1
XFILLER_0_8_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_62_121 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_47_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_165 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_7_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_53_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_38_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1631_ _0571_ _0738_ _0741_ _0649_ _0747_ VGND VGND VPWR VPWR _0748_ sky130_fd_sc_hd__o221a_1
X_1700_ net33 _0813_ VGND VGND VPWR VPWR _0814_ sky130_fd_sc_hd__xnor2_2
X_1493_ net11 _0588_ _0582_ VGND VGND VPWR VPWR _0612_ sky130_fd_sc_hd__a21oi_1
X_1562_ _0459_ _0676_ _0679_ _0603_ VGND VGND VPWR VPWR _0680_ sky130_fd_sc_hd__a22o_1
XFILLER_0_39_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2045_ _0001_ _0003_ VGND VGND VPWR VPWR _0004_ sky130_fd_sc_hd__xnor2_2
X_2114_ net19 net51 _0888_ _0075_ _0865_ VGND VGND VPWR VPWR _0076_ sky130_fd_sc_hd__a311o_1
XTAP_268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1829_ _0905_ _0679_ _0938_ VGND VGND VPWR VPWR _0939_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_44_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_23_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_25_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_279 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_41_33 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_41_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1614_ _0289_ _0667_ _0730_ VGND VGND VPWR VPWR _0731_ sky130_fd_sc_hd__nand3_1
XFILLER_0_26_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1476_ _0591_ _0594_ _0504_ VGND VGND VPWR VPWR _0595_ sky130_fd_sc_hd__mux2_1
X_1545_ _0663_ VGND VGND VPWR VPWR net80 sky130_fd_sc_hd__buf_1
XFILLER_0_5_33 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_49_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2028_ _1128_ _1129_ VGND VGND VPWR VPWR _1130_ sky130_fd_sc_hd__or2_1
XFILLER_0_64_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_13_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_63_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_308 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1330_ net37 net48 net62 net59 VGND VGND VPWR VPWR _0450_ sky130_fd_sc_hd__or4_4
X_1261_ net15 _0373_ _0380_ VGND VGND VPWR VPWR _0381_ sky130_fd_sc_hd__o21a_1
XFILLER_0_52_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1192_ _0146_ _0157_ _0292_ _0305_ _0311_ VGND VGND VPWR VPWR _0312_ sky130_fd_sc_hd__o221a_1
Xinput7 data_in1[11] VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_52_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_10_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_168 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1459_ _0188_ net29 VGND VGND VPWR VPWR _0578_ sky130_fd_sc_hd__nor2_1
X_1528_ _0545_ _0646_ VGND VGND VPWR VPWR _0647_ sky130_fd_sc_hd__or2_1
XFILLER_0_13_190 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_3_305 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_11_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_11_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2293_ _0497_ _0539_ _0542_ _0264_ _0501_ VGND VGND VPWR VPWR _0265_ sky130_fd_sc_hd__o311a_1
XFILLER_0_47_21 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_44_9 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1244_ net23 net55 VGND VGND VPWR VPWR _0364_ sky130_fd_sc_hd__xnor2_1
X_1313_ net54 net53 VGND VGND VPWR VPWR _0433_ sky130_fd_sc_hd__or2_1
XFILLER_0_63_42 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_59_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1175_ net31 _0293_ VGND VGND VPWR VPWR _0295_ sky130_fd_sc_hd__nand2_1
XFILLER_0_27_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput43 data_in2[15] VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__buf_2
Xinput32 data_in1[5] VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_56_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_56_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1862_ _0970_ _0852_ _0545_ VGND VGND VPWR VPWR _0971_ sky130_fd_sc_hd__mux2_1
X_1793_ _0783_ _0587_ _0842_ VGND VGND VPWR VPWR _0904_ sky130_fd_sc_hd__a21bo_1
X_1931_ _0724_ _1034_ _1036_ _0566_ VGND VGND VPWR VPWR _1037_ sky130_fd_sc_hd__o2bb2a_1
Xinput21 data_in1[24] VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__buf_4
XFILLER_0_3_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xinput54 data_in2[25] VGND VGND VPWR VPWR net54 sky130_fd_sc_hd__buf_2
Xinput10 data_in1[14] VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__buf_4
Xinput65 data_in2[6] VGND VGND VPWR VPWR net65 sky130_fd_sc_hd__buf_4
XFILLER_0_58_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_24_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1158_ _0178_ VGND VGND VPWR VPWR _0188_ sky130_fd_sc_hd__clkinv_4
X_2276_ _0352_ net58 _0744_ VGND VGND VPWR VPWR _0247_ sky130_fd_sc_hd__a21oi_1
X_1227_ net25 net57 VGND VGND VPWR VPWR _0347_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_59_193 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_15_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_61_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2130_ _0091_ _0014_ VGND VGND VPWR VPWR _0092_ sky130_fd_sc_hd__and2b_1
X_2061_ _0770_ _0796_ _0340_ VGND VGND VPWR VPWR _0020_ sky130_fd_sc_hd__mux2_1
XFILLER_0_56_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1914_ _0724_ _1020_ _0566_ _1010_ VGND VGND VPWR VPWR _1021_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_8_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1776_ _0428_ VGND VGND VPWR VPWR _0888_ sky130_fd_sc_hd__clkbuf_4
X_1845_ net39 _0922_ _0953_ VGND VGND VPWR VPWR _0954_ sky130_fd_sc_hd__nand3_1
XFILLER_0_8_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_12_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2259_ _0988_ _0198_ _0228_ _0446_ VGND VGND VPWR VPWR _0229_ sky130_fd_sc_hd__o22a_1
XFILLER_0_62_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_62_177 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_43_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1630_ net30 _0743_ _0746_ VGND VGND VPWR VPWR _0747_ sky130_fd_sc_hd__o21ai_1
X_1561_ _0677_ _0678_ _0480_ VGND VGND VPWR VPWR _0679_ sky130_fd_sc_hd__mux2_1
X_1492_ _0607_ _0610_ _0469_ VGND VGND VPWR VPWR _0611_ sky130_fd_sc_hd__mux2_1
XFILLER_0_39_99 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_39_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2044_ _0373_ _0002_ VGND VGND VPWR VPWR _0003_ sky130_fd_sc_hd__xnor2_2
X_2113_ net19 net51 _0796_ VGND VGND VPWR VPWR _0075_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_32_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1828_ _0461_ _0683_ VGND VGND VPWR VPWR _0938_ sky130_fd_sc_hd__or2_1
XFILLER_0_25_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1759_ net66 net65 net64 net63 VGND VGND VPWR VPWR _0871_ sky130_fd_sc_hd__or4_4
XFILLER_0_25_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1544_ _0637_ _0644_ _0650_ _0662_ VGND VGND VPWR VPWR _0663_ sky130_fd_sc_hd__or4_1
X_1613_ net37 net48 net59 VGND VGND VPWR VPWR _0730_ sky130_fd_sc_hd__or3_2
X_1475_ _0592_ _0593_ VGND VGND VPWR VPWR _0594_ sky130_fd_sc_hd__or2_1
XFILLER_0_5_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_311 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2027_ _1075_ _1086_ _1106_ _1108_ VGND VGND VPWR VPWR _1129_ sky130_fd_sc_hd__a31o_1
XFILLER_0_32_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_23_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1191_ _0304_ _0310_ VGND VGND VPWR VPWR _0311_ sky130_fd_sc_hd__or2_1
Xinput8 data_in1[12] VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__clkbuf_4
X_1260_ _0356_ _0357_ _0375_ _0379_ VGND VGND VPWR VPWR _0380_ sky130_fd_sc_hd__a22o_1
XFILLER_0_54_294 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_54_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1527_ _0495_ _0645_ VGND VGND VPWR VPWR _0646_ sky130_fd_sc_hd__or2_1
X_1389_ _0505_ _0507_ _0508_ VGND VGND VPWR VPWR _0509_ sky130_fd_sc_hd__or3_1
X_1458_ _0495_ _0564_ VGND VGND VPWR VPWR _0577_ sky130_fd_sc_hd__nor2_1
XFILLER_0_60_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_45_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_317 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2292_ _0426_ _0532_ _0538_ _0626_ VGND VGND VPWR VPWR _0264_ sky130_fd_sc_hd__a211o_1
XFILLER_0_47_33 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1174_ net31 _0293_ VGND VGND VPWR VPWR _0294_ sky130_fd_sc_hd__or2_1
X_1243_ net21 net53 VGND VGND VPWR VPWR _0363_ sky130_fd_sc_hd__xnor2_1
X_1312_ net58 net57 net56 net55 VGND VGND VPWR VPWR _0432_ sky130_fd_sc_hd__or4_4
XFILLER_0_63_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_56_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1930_ _0905_ _0821_ _1035_ VGND VGND VPWR VPWR _1036_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_33_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput55 data_in2[26] VGND VGND VPWR VPWR net55 sky130_fd_sc_hd__clkbuf_4
Xinput22 data_in1[25] VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_56_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xinput11 data_in1[15] VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__clkbuf_4
X_1861_ _0911_ _0969_ _0626_ VGND VGND VPWR VPWR _0970_ sky130_fd_sc_hd__mux2_1
X_1792_ _0882_ _0883_ _0897_ _0903_ VGND VGND VPWR VPWR net99 sky130_fd_sc_hd__a211o_1
XFILLER_0_24_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_3_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xinput44 data_in2[16] VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__buf_4
Xinput33 data_in1[6] VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__buf_4
XFILLER_0_16_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput66 data_in2[7] VGND VGND VPWR VPWR net66 sky130_fd_sc_hd__buf_4
XFILLER_0_58_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1157_ net48 VGND VGND VPWR VPWR _0178_ sky130_fd_sc_hd__buf_4
X_2275_ _0898_ _0245_ VGND VGND VPWR VPWR _0246_ sky130_fd_sc_hd__nor2_1
X_1226_ _0343_ _0344_ _0345_ VGND VGND VPWR VPWR _0346_ sky130_fd_sc_hd__or3b_1
XFILLER_0_30_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_38_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_128 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_21_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2060_ _0005_ _0006_ _0018_ VGND VGND VPWR VPWR net79 sky130_fd_sc_hd__o21ai_1
XFILLER_0_60_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_109 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_44_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1913_ _0742_ _0784_ _0842_ VGND VGND VPWR VPWR _1020_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_8_217 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1775_ _0743_ _0546_ _0724_ VGND VGND VPWR VPWR _0887_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_4_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1844_ net38 _0930_ _0450_ _0871_ VGND VGND VPWR VPWR _0953_ sky130_fd_sc_hd__or4_1
XFILLER_0_33_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2258_ _0998_ _0227_ _0554_ VGND VGND VPWR VPWR _0228_ sky130_fd_sc_hd__mux2_1
X_2189_ _0152_ _0154_ _0514_ VGND VGND VPWR VPWR _0155_ sky130_fd_sc_hd__a21o_1
X_1209_ _0327_ _0328_ VGND VGND VPWR VPWR _0329_ sky130_fd_sc_hd__nand2_1
XFILLER_0_62_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1560_ _0525_ _0536_ _0495_ VGND VGND VPWR VPWR _0678_ sky130_fd_sc_hd__mux2_1
XFILLER_0_53_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1491_ _0608_ _0609_ VGND VGND VPWR VPWR _0610_ sky130_fd_sc_hd__or2_1
X_2112_ _0743_ _0831_ _0071_ _0073_ _0515_ VGND VGND VPWR VPWR _0074_ sky130_fd_sc_hd__o32a_1
XTAP_204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2043_ net46 net45 net44 _1072_ _0922_ VGND VGND VPWR VPWR _0002_ sky130_fd_sc_hd__o41a_1
X_1827_ _0905_ _0676_ _0842_ VGND VGND VPWR VPWR _0937_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_17_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1758_ _0870_ VGND VGND VPWR VPWR net98 sky130_fd_sc_hd__clkbuf_1
X_1689_ net64 _0803_ VGND VGND VPWR VPWR _0804_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_4_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_20_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_123 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_35_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_26_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1474_ net14 _0588_ _0424_ VGND VGND VPWR VPWR _0593_ sky130_fd_sc_hd__a21boi_1
X_1543_ _0658_ _0659_ _0661_ _0209_ VGND VGND VPWR VPWR _0662_ sky130_fd_sc_hd__a22o_1
X_1612_ _0724_ _0721_ _0728_ _0458_ VGND VGND VPWR VPWR _0729_ sky130_fd_sc_hd__o211a_1
XFILLER_0_1_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_57_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_9_323 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2026_ _0374_ _1127_ VGND VGND VPWR VPWR _1128_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_17_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput9 data_in1[13] VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__buf_4
X_1190_ _0298_ _0308_ _0309_ VGND VGND VPWR VPWR _0310_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_14_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1457_ _0425_ _0574_ _0575_ VGND VGND VPWR VPWR _0576_ sky130_fd_sc_hd__o21a_1
X_1526_ _0425_ _0444_ _0630_ VGND VGND VPWR VPWR _0645_ sky130_fd_sc_hd__a21o_1
XFILLER_0_10_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_10_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1388_ net30 _0442_ _0241_ VGND VGND VPWR VPWR _0508_ sky130_fd_sc_hd__a21boi_1
X_2009_ _0592_ _0613_ VGND VGND VPWR VPWR _1112_ sky130_fd_sc_hd__or2_1
XFILLER_0_60_265 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_60_221 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_13_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_51_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1311_ _0426_ net5 _0428_ _0430_ VGND VGND VPWR VPWR _0431_ sky130_fd_sc_hd__a31o_1
X_2291_ _0905_ _0884_ _0458_ _0835_ _0261_ VGND VGND VPWR VPWR _0263_ sky130_fd_sc_hd__a41o_1
XFILLER_0_47_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1173_ net63 VGND VGND VPWR VPWR _0293_ sky130_fd_sc_hd__clkbuf_4
X_1242_ net24 net56 VGND VGND VPWR VPWR _0362_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_63_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1509_ net27 net111 VGND VGND VPWR VPWR _0628_ sky130_fd_sc_hd__nand2_1
XFILLER_0_18_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_295 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_33_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_56_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1860_ _0605_ _0609_ VGND VGND VPWR VPWR _0969_ sky130_fd_sc_hd__or2_1
Xinput34 data_in1[7] VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__clkbuf_1
Xinput45 data_in2[17] VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__clkbuf_4
X_1791_ _0899_ _0902_ _0552_ VGND VGND VPWR VPWR _0903_ sky130_fd_sc_hd__o21a_1
Xinput67 data_in2[8] VGND VGND VPWR VPWR net67 sky130_fd_sc_hd__buf_2
XFILLER_0_3_137 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xinput56 data_in2[27] VGND VGND VPWR VPWR net56 sky130_fd_sc_hd__buf_2
Xinput12 data_in1[16] VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__buf_4
Xinput23 data_in1[26] VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__buf_4
XFILLER_0_58_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2274_ _1020_ _0198_ _0244_ _1101_ VGND VGND VPWR VPWR _0245_ sky130_fd_sc_hd__o22a_1
X_1156_ net30 net62 VGND VGND VPWR VPWR _0167_ sky130_fd_sc_hd__xor2_1
X_1225_ net19 net51 VGND VGND VPWR VPWR _0345_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_47_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1989_ net12 net44 _0865_ _1092_ VGND VGND VPWR VPWR _1093_ sky130_fd_sc_hd__o22a_1
XFILLER_0_30_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_305 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_61_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_53_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_0_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1912_ _0458_ _1011_ _1012_ _1018_ VGND VGND VPWR VPWR _1019_ sky130_fd_sc_hd__a31o_1
X_1843_ net6 _0932_ VGND VGND VPWR VPWR _0952_ sky130_fd_sc_hd__nand2_1
XFILLER_0_8_229 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1774_ _0884_ _0885_ VGND VGND VPWR VPWR _0886_ sky130_fd_sc_hd__nand2_1
XFILLER_0_12_268 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2257_ _0459_ _0023_ _0128_ _0492_ _0226_ VGND VGND VPWR VPWR _0227_ sky130_fd_sc_hd__a221o_1
X_1208_ net8 net40 VGND VGND VPWR VPWR _0328_ sky130_fd_sc_hd__nand2_1
XFILLER_0_47_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2188_ _0461_ _0456_ _0641_ _0904_ _0550_ VGND VGND VPWR VPWR _0154_ sky130_fd_sc_hd__o32a_1
XFILLER_0_43_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_14_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1490_ net6 _0443_ _0498_ VGND VGND VPWR VPWR _0609_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_39_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2111_ _0550_ _0823_ _0837_ _0456_ _0071_ VGND VGND VPWR VPWR _0073_ sky130_fd_sc_hd__o221a_1
XTAP_216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2042_ net15 VGND VGND VPWR VPWR _0001_ sky130_fd_sc_hd__inv_2
XTAP_238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1826_ _0572_ _0935_ VGND VGND VPWR VPWR _0936_ sky130_fd_sc_hd__nor2_1
XFILLER_0_4_265 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_4_221 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_17_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1757_ _0850_ _0854_ _0858_ _0869_ VGND VGND VPWR VPWR _0870_ sky130_fd_sc_hd__or4_1
X_1688_ net63 _0451_ _0667_ VGND VGND VPWR VPWR _0803_ sky130_fd_sc_hd__o21a_1
X_2309_ _0626_ _0575_ _0638_ VGND VGND VPWR VPWR _0281_ sky130_fd_sc_hd__and3_1
XFILLER_0_35_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_41_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1611_ _0724_ _0727_ VGND VGND VPWR VPWR _0728_ sky130_fd_sc_hd__nand2_1
X_1473_ net13 _0588_ _0582_ VGND VGND VPWR VPWR _0592_ sky130_fd_sc_hd__a21oi_1
X_1542_ net16 _0497_ _0428_ _0660_ _0429_ VGND VGND VPWR VPWR _0661_ sky130_fd_sc_hd__a311o_1
XFILLER_0_5_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_22_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2025_ net46 _1126_ VGND VGND VPWR VPWR _1127_ sky130_fd_sc_hd__xor2_1
XFILLER_0_64_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_9_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_92 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1809_ _0458_ _0909_ _0910_ _0919_ _0664_ VGND VGND VPWR VPWR _0920_ sky130_fd_sc_hd__a311o_1
XFILLER_0_13_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1456_ _0425_ net28 _0506_ VGND VGND VPWR VPWR _0575_ sky130_fd_sc_hd__nand3_1
X_1387_ net27 _0506_ _0426_ VGND VGND VPWR VPWR _0507_ sky130_fd_sc_hd__a21oi_1
X_1525_ _0514_ _0635_ _0643_ _0457_ VGND VGND VPWR VPWR _0644_ sky130_fd_sc_hd__o211a_1
XFILLER_0_10_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_10_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2008_ _1109_ _1110_ VGND VGND VPWR VPWR _1111_ sky130_fd_sc_hd__xor2_1
XFILLER_0_45_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_277 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_60_233 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_5_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1310_ _0426_ net5 _0429_ VGND VGND VPWR VPWR _0430_ sky130_fd_sc_hd__o21a_1
X_2290_ net28 net60 _0865_ _0260_ VGND VGND VPWR VPWR _0261_ sky130_fd_sc_hd__o22a_1
X_1241_ _0356_ _0357_ _0358_ _0359_ _0360_ VGND VGND VPWR VPWR _0361_ sky130_fd_sc_hd__a221o_1
X_1172_ _0167_ _0288_ _0291_ VGND VGND VPWR VPWR _0292_ sky130_fd_sc_hd__o21a_1
XFILLER_0_2_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_27_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput100 net100 VGND VGND VPWR VPWR data_out[9] sky130_fd_sc_hd__buf_2
XFILLER_0_2_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1508_ _0622_ _0625_ _0626_ VGND VGND VPWR VPWR _0627_ sky130_fd_sc_hd__mux2_1
X_1439_ _0558_ VGND VGND VPWR VPWR _0559_ sky130_fd_sc_hd__inv_2
XFILLER_0_10_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_17_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1790_ _0515_ _0900_ _0885_ _0901_ VGND VGND VPWR VPWR _0902_ sky130_fd_sc_hd__a22oi_1
Xinput13 data_in1[17] VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__buf_4
Xinput46 data_in2[18] VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__buf_4
Xinput24 data_in1[27] VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__clkbuf_4
Xinput35 data_in1[8] VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__buf_4
XFILLER_0_24_277 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_3_149 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_3_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput68 data_in2[9] VGND VGND VPWR VPWR net68 sky130_fd_sc_hd__buf_2
Xinput57 data_in2[28] VGND VGND VPWR VPWR net57 sky130_fd_sc_hd__clkbuf_4
X_2273_ _1015_ _0243_ _0554_ VGND VGND VPWR VPWR _0244_ sky130_fd_sc_hd__mux2_1
X_1224_ net18 net50 VGND VGND VPWR VPWR _0344_ sky130_fd_sc_hd__xor2_1
X_1155_ net66 VGND VGND VPWR VPWR _0157_ sky130_fd_sc_hd__inv_2
XFILLER_0_55_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1988_ net12 net44 _0888_ _1091_ VGND VGND VPWR VPWR _1092_ sky130_fd_sc_hd__a31o_1
XFILLER_0_53_317 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_38_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_21_203 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_21_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_56_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_317 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1773_ _0482_ _0530_ _0547_ VGND VGND VPWR VPWR _0885_ sky130_fd_sc_hd__mux2_1
X_1842_ _0934_ _0936_ _0941_ _0951_ VGND VGND VPWR VPWR net70 sky130_fd_sc_hd__a211o_1
X_1911_ _0891_ _1015_ _1017_ VGND VGND VPWR VPWR _1018_ sky130_fd_sc_hd__o21ai_1
X_2256_ _0505_ _0172_ _0225_ _0500_ VGND VGND VPWR VPWR _0226_ sky130_fd_sc_hd__o211a_1
X_2187_ _0916_ _0152_ VGND VGND VPWR VPWR _0153_ sky130_fd_sc_hd__or2_1
XFILLER_0_19_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1207_ net8 net40 VGND VGND VPWR VPWR _0327_ sky130_fd_sc_hd__or2_1
XFILLER_0_47_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_43_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_30_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_339 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_19_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2110_ _1040_ _0010_ _0070_ _0014_ _0446_ VGND VGND VPWR VPWR _0071_ sky130_fd_sc_hd__a221o_1
X_2041_ _0374_ _1127_ VGND VGND VPWR VPWR _0000_ sky130_fd_sc_hd__or2_1
XFILLER_0_32_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1756_ _0664_ _0864_ _0868_ VGND VGND VPWR VPWR _0869_ sky130_fd_sc_hd__a21o_1
XFILLER_0_29_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1825_ _0925_ _0929_ net120 VGND VGND VPWR VPWR _0935_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_4_277 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_4_233 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_20_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2308_ _0193_ VGND VGND VPWR VPWR _0280_ sky130_fd_sc_hd__inv_2
X_1687_ _0512_ _0801_ VGND VGND VPWR VPWR _0802_ sky130_fd_sc_hd__nand2_1
X_2239_ net25 net57 _0422_ VGND VGND VPWR VPWR _0207_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_35_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_25_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1610_ _0713_ _0726_ _0461_ VGND VGND VPWR VPWR _0727_ sky130_fd_sc_hd__mux2_1
XFILLER_0_26_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_14_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_22_331 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1472_ _0589_ _0590_ VGND VGND VPWR VPWR _0591_ sky130_fd_sc_hd__or2_1
X_1541_ _0421_ _0220_ VGND VGND VPWR VPWR _0660_ sky130_fd_sc_hd__and2b_1
X_2024_ net45 net44 _1072_ _0922_ VGND VGND VPWR VPWR _1126_ sky130_fd_sc_hd__o31a_1
XFILLER_0_57_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_17_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1739_ _0792_ _0851_ _0505_ VGND VGND VPWR VPWR _0852_ sky130_fd_sc_hd__mux2_1
X_1808_ _0891_ _0916_ _0918_ VGND VGND VPWR VPWR _0919_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_31_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_54_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1524_ _0514_ _0642_ VGND VGND VPWR VPWR _0643_ sky130_fd_sc_hd__nand2_1
XFILLER_0_14_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1455_ _0352_ _0506_ VGND VGND VPWR VPWR _0574_ sky130_fd_sc_hd__nand2_1
X_1386_ _0462_ VGND VGND VPWR VPWR _0506_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_10_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_9_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2007_ _1075_ _1086_ VGND VGND VPWR VPWR _1110_ sky130_fd_sc_hd__nand2_1
XFILLER_0_18_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_9_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_289 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_209 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1171_ net30 _0290_ VGND VGND VPWR VPWR _0291_ sky130_fd_sc_hd__or2_1
X_1240_ net14 net46 VGND VGND VPWR VPWR _0360_ sky130_fd_sc_hd__xor2_1
XFILLER_0_63_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_2_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1507_ _0505_ VGND VGND VPWR VPWR _0626_ sky130_fd_sc_hd__clkbuf_4
X_1369_ net32 _0462_ _0471_ VGND VGND VPWR VPWR _0489_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_49_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1438_ _0540_ _0557_ _0178_ VGND VGND VPWR VPWR _0558_ sky130_fd_sc_hd__mux2_1
XFILLER_0_10_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_231 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_18_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_17_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xinput14 data_in1[18] VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__buf_4
Xinput25 data_in1[28] VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__clkbuf_4
Xinput36 data_in1[9] VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__clkbuf_4
Xinput58 data_in2[29] VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__buf_4
XFILLER_0_24_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput47 data_in2[19] VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__clkbuf_2
X_1154_ net34 VGND VGND VPWR VPWR _0146_ sky130_fd_sc_hd__buf_4
X_2272_ _0459_ _0050_ _0149_ _0492_ _0242_ VGND VGND VPWR VPWR _0243_ sky130_fd_sc_hd__a221o_1
XFILLER_0_35_9 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1223_ _0339_ _0340_ _0341_ _0342_ VGND VGND VPWR VPWR _0343_ sky130_fd_sc_hd__a22o_1
XFILLER_0_62_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_30_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1987_ net12 net44 _0422_ VGND VGND VPWR VPWR _1091_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_15_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_81 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_53_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_348 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_61_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_21_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1910_ _0768_ _1016_ _0323_ VGND VGND VPWR VPWR _1017_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_44_329 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1772_ _0554_ VGND VGND VPWR VPWR _0884_ sky130_fd_sc_hd__clkbuf_4
X_1841_ _0944_ _0946_ _0950_ VGND VGND VPWR VPWR _0951_ sky130_fd_sc_hd__or3b_1
XFILLER_0_8_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2255_ _0426_ _0532_ _0538_ _0495_ VGND VGND VPWR VPWR _0225_ sky130_fd_sc_hd__a211o_1
X_2186_ _0884_ _0151_ _0446_ VGND VGND VPWR VPWR _0152_ sky130_fd_sc_hd__a21o_1
X_1206_ net10 net42 VGND VGND VPWR VPWR _0326_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_47_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_264 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_50_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_11_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_61_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_38_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2040_ _0665_ _1130_ _1131_ _1141_ VGND VGND VPWR VPWR net78 sky130_fd_sc_hd__a31o_1
XFILLER_0_44_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1686_ _0783_ _0695_ _0639_ _0800_ VGND VGND VPWR VPWR _0801_ sky130_fd_sc_hd__o31a_1
X_1755_ _0146_ net66 _0865_ _0867_ VGND VGND VPWR VPWR _0868_ sky130_fd_sc_hd__o22a_1
XFILLER_0_25_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1824_ _0925_ _0929_ net119 VGND VGND VPWR VPWR _0934_ sky130_fd_sc_hd__nand3_2
XFILLER_0_4_289 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_4_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_29_70 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2238_ _0994_ _1120_ VGND VGND VPWR VPWR _0206_ sky130_fd_sc_hd__nor2_1
X_2307_ _0370_ _0550_ _0571_ _0278_ VGND VGND VPWR VPWR _0279_ sky130_fd_sc_hd__o211ai_1
X_2169_ net53 _0109_ _0042_ VGND VGND VPWR VPWR _0133_ sky130_fd_sc_hd__o21a_1
XFILLER_0_0_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_354 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_58_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1540_ _0408_ _0657_ _0571_ VGND VGND VPWR VPWR _0659_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_1_237 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_22_343 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_22_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1471_ net17 _0588_ _0424_ VGND VGND VPWR VPWR _0590_ sky130_fd_sc_hd__a21boi_1
X_2023_ _0665_ _1111_ _1125_ VGND VGND VPWR VPWR net77 sky130_fd_sc_hd__a21o_1
X_1807_ _0768_ _0917_ _0072_ VGND VGND VPWR VPWR _0918_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_9_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_17_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_137 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1738_ _0620_ _0624_ VGND VGND VPWR VPWR _0851_ sky130_fd_sc_hd__or2_1
X_1669_ _0640_ _0579_ _0707_ VGND VGND VPWR VPWR _0784_ sky130_fd_sc_hd__o21a_1
XTAP_593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_254 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_31_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1523_ _0602_ _0641_ _0555_ VGND VGND VPWR VPWR _0642_ sky130_fd_sc_hd__mux2_1
X_1454_ _0414_ _0454_ _0570_ _0572_ _0573_ VGND VGND VPWR VPWR net69 sky130_fd_sc_hd__o32a_1
XFILLER_0_10_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1385_ _0504_ VGND VGND VPWR VPWR _0505_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_45_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2006_ _1107_ _1108_ VGND VGND VPWR VPWR _1109_ sky130_fd_sc_hd__nor2_1
XFILLER_0_45_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1170_ _0289_ VGND VGND VPWR VPWR _0290_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_63_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1506_ _0623_ _0624_ VGND VGND VPWR VPWR _0625_ sky130_fd_sc_hd__or2_1
X_1437_ _0471_ _0370_ _0542_ VGND VGND VPWR VPWR _0557_ sky130_fd_sc_hd__a21o_1
XFILLER_0_2_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1368_ net31 net111 _0471_ VGND VGND VPWR VPWR _0488_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_37_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1299_ _0398_ _0418_ VGND VGND VPWR VPWR _0419_ sky130_fd_sc_hd__nand2_1
XFILLER_0_53_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_33_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xinput15 data_in1[19] VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__clkbuf_4
Xinput26 data_in1[29] VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__buf_1
Xinput37 data_in2[0] VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__buf_6
Xinput59 data_in2[2] VGND VGND VPWR VPWR net59 sky130_fd_sc_hd__clkbuf_4
Xinput48 data_in2[1] VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__buf_4
X_2271_ _0497_ _0239_ _0240_ VGND VGND VPWR VPWR _0242_ sky130_fd_sc_hd__o21a_1
X_1153_ _0051_ _0061_ _0093_ _0125_ VGND VGND VPWR VPWR _0135_ sky130_fd_sc_hd__nand4_2
X_1222_ net20 net52 VGND VGND VPWR VPWR _0342_ sky130_fd_sc_hd__nand2_1
XFILLER_0_47_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_47_305 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1986_ _1089_ VGND VGND VPWR VPWR _1090_ sky130_fd_sc_hd__buf_2
XFILLER_0_61_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_55_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_30_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_93 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_61_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1840_ _0061_ _0796_ _0891_ _0949_ VGND VGND VPWR VPWR _0950_ sky130_fd_sc_hd__o22a_1
XFILLER_0_52_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1771_ _0876_ _0881_ _0572_ VGND VGND VPWR VPWR _0883_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_8_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2254_ _0222_ _0212_ _0215_ VGND VGND VPWR VPWR _0224_ sky130_fd_sc_hd__and3_1
X_2185_ _0460_ _1113_ _0150_ VGND VGND VPWR VPWR _0151_ sky130_fd_sc_hd__a21o_1
XFILLER_0_47_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1205_ _0323_ _0324_ VGND VGND VPWR VPWR _0325_ sky130_fd_sc_hd__nand2_1
XFILLER_0_34_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1969_ _0922_ net116 VGND VGND VPWR VPWR _1073_ sky130_fd_sc_hd__nand2_1
XFILLER_0_43_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_193 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_34_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_19_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_55_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_39_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1823_ net6 _0932_ VGND VGND VPWR VPWR _0933_ sky130_fd_sc_hd__xor2_1
XFILLER_0_40_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1685_ _0555_ _0782_ VGND VGND VPWR VPWR _0800_ sky130_fd_sc_hd__or2_1
X_1754_ _0146_ net66 _0428_ _0866_ VGND VGND VPWR VPWR _0867_ sky130_fd_sc_hd__a31o_1
XFILLER_0_25_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2237_ _0665_ _0189_ _0201_ _0205_ VGND VGND VPWR VPWR net88 sky130_fd_sc_hd__a211o_1
X_2306_ _0350_ _0796_ _0768_ _0348_ VGND VGND VPWR VPWR _0278_ sky130_fd_sc_hd__o22a_1
X_2099_ _0665_ _0048_ _0059_ VGND VGND VPWR VPWR net82 sky130_fd_sc_hd__a21o_1
XFILLER_0_0_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2168_ net105 _0117_ _0132_ VGND VGND VPWR VPWR net85 sky130_fd_sc_hd__o21ai_2
XFILLER_0_43_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_366 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1470_ net15 _0588_ _0498_ VGND VGND VPWR VPWR _0589_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_34_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_1_205 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_1_249 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_22_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2022_ _1117_ _1124_ VGND VGND VPWR VPWR _1125_ sky130_fd_sc_hd__nand2_1
XFILLER_0_9_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_15_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_73 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1806_ _0769_ _0744_ _0082_ VGND VGND VPWR VPWR _0917_ sky130_fd_sc_hd__mux2_1
XFILLER_0_17_149 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1599_ _0594_ _0614_ _0504_ VGND VGND VPWR VPWR _0716_ sky130_fd_sc_hd__mux2_1
X_1668_ _0290_ VGND VGND VPWR VPWR _0783_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_40_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1737_ _0553_ _0849_ _0551_ VGND VGND VPWR VPWR _0850_ sky130_fd_sc_hd__o21a_1
XFILLER_0_0_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_266 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_31_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1522_ _0585_ _0639_ _0640_ VGND VGND VPWR VPWR _0641_ sky130_fd_sc_hd__mux2_1
X_1453_ _0409_ VGND VGND VPWR VPWR _0573_ sky130_fd_sc_hd__inv_2
X_1384_ _0188_ VGND VGND VPWR VPWR _0504_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_26_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2005_ net13 _1105_ VGND VGND VPWR VPWR _1108_ sky130_fd_sc_hd__nor2_1
XFILLER_0_42_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_288 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_51_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_2_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_6_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1367_ _0441_ VGND VGND VPWR VPWR _0487_ sky130_fd_sc_hd__buf_6
X_1505_ net33 _0506_ _0498_ VGND VGND VPWR VPWR _0624_ sky130_fd_sc_hd__a21boi_1
X_1436_ _0555_ _0530_ VGND VGND VPWR VPWR _0556_ sky130_fd_sc_hd__nor2_1
XFILLER_0_2_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_53_70 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1298_ net4 net3 VGND VGND VPWR VPWR _0418_ sky130_fd_sc_hd__nand2_2
XFILLER_0_33_203 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_18_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_193 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_49_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput27 data_in1[2] VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__clkbuf_4
Xinput16 data_in1[1] VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__clkbuf_4
Xinput38 data_in2[10] VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__clkbuf_4
Xinput49 data_in2[20] VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_58_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2270_ _0497_ _0191_ _0993_ VGND VGND VPWR VPWR _0240_ sky130_fd_sc_hd__a21oi_1
X_1221_ net20 net52 VGND VGND VPWR VPWR _0341_ sky130_fd_sc_hd__or2_1
XFILLER_0_59_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1152_ _0103_ _0114_ VGND VGND VPWR VPWR _0125_ sky130_fd_sc_hd__nand2_1
XFILLER_0_62_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_55_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_47_317 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1985_ net29 _1088_ _0448_ VGND VGND VPWR VPWR _1089_ sky130_fd_sc_hd__and3_2
XFILLER_0_23_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_239 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_2_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1419_ net26 net104 _0241_ VGND VGND VPWR VPWR _0539_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_54_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_48_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_60_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_158 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_29_317 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1770_ _0876_ _0881_ VGND VGND VPWR VPWR _0882_ sky130_fd_sc_hd__or2_1
XFILLER_0_64_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2184_ _0492_ _0147_ _0149_ _0500_ VGND VGND VPWR VPWR _0150_ sky130_fd_sc_hd__a22o_1
XFILLER_0_26_7 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2253_ _0212_ _0215_ _0222_ VGND VGND VPWR VPWR _0223_ sky130_fd_sc_hd__a21oi_2
X_1204_ net9 net41 VGND VGND VPWR VPWR _0324_ sky130_fd_sc_hd__nand2_1
XFILLER_0_34_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1899_ net9 _1005_ VGND VGND VPWR VPWR _1006_ sky130_fd_sc_hd__xnor2_2
X_1968_ _0438_ net121 net103 net124 VGND VGND VPWR VPWR _1072_ sky130_fd_sc_hd__or4_4
XFILLER_0_19_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_61_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_55_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1753_ _0146_ net66 _0744_ VGND VGND VPWR VPWR _0866_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_25_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1822_ net38 _0931_ VGND VGND VPWR VPWR _0932_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_17_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_20_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_40_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1684_ _0699_ _0789_ VGND VGND VPWR VPWR _0799_ sky130_fd_sc_hd__or2_1
XFILLER_0_20_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2167_ _0448_ _0119_ _0131_ VGND VGND VPWR VPWR _0132_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_29_94 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2305_ _1057_ _1120_ VGND VGND VPWR VPWR _0277_ sky130_fd_sc_hd__nor2_1
X_2236_ _1090_ _0204_ VGND VGND VPWR VPWR _0205_ sky130_fd_sc_hd__or2_1
XFILLER_0_17_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_61_81 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_48_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2098_ _0052_ _0053_ _0058_ VGND VGND VPWR VPWR _0059_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_43_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_378 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_22_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_1_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2021_ _0604_ _1118_ _1120_ _0642_ _1123_ VGND VGND VPWR VPWR _1124_ sky130_fd_sc_hd__o221a_1
XFILLER_0_15_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_40_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1805_ _0547_ _0914_ _0915_ VGND VGND VPWR VPWR _0916_ sky130_fd_sc_hd__o21ai_1
X_1736_ _0511_ _0845_ _0848_ _0566_ VGND VGND VPWR VPWR _0849_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_31_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1598_ _0617_ _0607_ _0505_ VGND VGND VPWR VPWR _0715_ sky130_fd_sc_hd__mux2_1
X_1667_ _0601_ _0585_ _0481_ VGND VGND VPWR VPWR _0782_ sky130_fd_sc_hd__mux2_1
XFILLER_0_40_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2219_ _0161_ net23 VGND VGND VPWR VPWR _0186_ sky130_fd_sc_hd__and2b_1
XFILLER_0_63_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_63_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_6_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_16_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_6_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1521_ _0560_ VGND VGND VPWR VPWR _0640_ sky130_fd_sc_hd__clkbuf_4
X_1383_ _0444_ _0502_ VGND VGND VPWR VPWR _0503_ sky130_fd_sc_hd__or2_2
X_1452_ _0571_ VGND VGND VPWR VPWR _0572_ sky130_fd_sc_hd__buf_4
XFILLER_0_22_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2004_ _1106_ VGND VGND VPWR VPWR _1107_ sky130_fd_sc_hd__inv_2
XFILLER_0_9_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1719_ _0767_ _0832_ _0296_ VGND VGND VPWR VPWR _0833_ sky130_fd_sc_hd__a21bo_1
XTAP_392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_6_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1504_ net32 _0588_ _0498_ VGND VGND VPWR VPWR _0623_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_2_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_2_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_2_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1366_ _0484_ _0485_ VGND VGND VPWR VPWR _0486_ sky130_fd_sc_hd__or2_1
X_1435_ _0459_ VGND VGND VPWR VPWR _0555_ sky130_fd_sc_hd__clkbuf_4
X_1297_ net4 net3 VGND VGND VPWR VPWR _0417_ sky130_fd_sc_hd__nor2_1
XFILLER_0_33_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xinput28 data_in1[30] VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__buf_4
Xinput17 data_in1[20] VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__buf_4
XFILLER_0_58_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput39 data_in2[11] VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__buf_4
XFILLER_0_32_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1151_ net35 net67 VGND VGND VPWR VPWR _0114_ sky130_fd_sc_hd__nand2_1
X_1220_ net17 net49 VGND VGND VPWR VPWR _0340_ sky130_fd_sc_hd__nand2_1
XFILLER_0_59_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1984_ net3 net4 _0406_ _0398_ VGND VGND VPWR VPWR _1088_ sky130_fd_sc_hd__and4b_1
XFILLER_0_23_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_2_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_64_70 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1349_ _0188_ VGND VGND VPWR VPWR _0469_ sky130_fd_sc_hd__buf_4
X_1418_ net25 net104 _0241_ VGND VGND VPWR VPWR _0538_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_3_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_52_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_8_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_52_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2183_ _0088_ _0148_ _0469_ VGND VGND VPWR VPWR _0149_ sky130_fd_sc_hd__mux2_1
X_2252_ _0219_ _0221_ VGND VGND VPWR VPWR _0222_ sky130_fd_sc_hd__or2_1
XFILLER_0_18_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1203_ net9 net41 VGND VGND VPWR VPWR _0323_ sky130_fd_sc_hd__or2_1
XFILLER_0_20_295 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_28_351 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_50_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1967_ _0665_ _1056_ _1069_ _1071_ VGND VGND VPWR VPWR net75 sky130_fd_sc_hd__a211o_1
X_1898_ net41 _1004_ VGND VGND VPWR VPWR _1005_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_59_81 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_19_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_34_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_55_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_52_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1683_ _0649_ _0794_ _0797_ VGND VGND VPWR VPWR _0798_ sky130_fd_sc_hd__o21ai_1
X_1752_ _0429_ VGND VGND VPWR VPWR _0865_ sky130_fd_sc_hd__clkbuf_4
X_1821_ _0930_ _0451_ _0871_ _0652_ VGND VGND VPWR VPWR _0931_ sky130_fd_sc_hd__o31a_1
XFILLER_0_20_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2304_ _0270_ _0271_ _0274_ VGND VGND VPWR VPWR _0276_ sky130_fd_sc_hd__a21oi_1
X_2097_ _0786_ _1118_ _1120_ _0801_ _0057_ VGND VGND VPWR VPWR _0058_ sky130_fd_sc_hd__o221a_1
X_2166_ _1089_ _0121_ _0124_ _0130_ VGND VGND VPWR VPWR _0131_ sky130_fd_sc_hd__or4_1
X_2235_ net24 net56 _0865_ _0203_ VGND VGND VPWR VPWR _0204_ sky130_fd_sc_hd__o22a_1
XFILLER_0_61_93 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_0_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_31_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_9_83 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_16_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xsplit11 _0487_ VGND VGND VPWR VPWR net111 sky130_fd_sc_hd__clkbuf_2
X_2020_ _0358_ _1122_ _1090_ VGND VGND VPWR VPWR _1123_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_57_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1735_ _0501_ _0718_ _0847_ VGND VGND VPWR VPWR _0848_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_40_165 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_40_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1666_ _0665_ _0757_ _0758_ _0781_ VGND VGND VPWR VPWR net95 sky130_fd_sc_hd__a31o_2
X_1804_ _0547_ _0647_ VGND VGND VPWR VPWR _0915_ sky130_fd_sc_hd__nand2_1
XFILLER_0_13_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1597_ _0461_ _0710_ _0713_ _0603_ VGND VGND VPWR VPWR _0714_ sky130_fd_sc_hd__a22o_1
XFILLER_0_0_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2149_ net21 _0110_ VGND VGND VPWR VPWR _0112_ sky130_fd_sc_hd__nor2_1
X_2218_ _0183_ _0184_ VGND VGND VPWR VPWR _0185_ sky130_fd_sc_hd__nor2_1
XFILLER_0_48_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_39_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1520_ _0576_ _0638_ _0496_ VGND VGND VPWR VPWR _0639_ sky130_fd_sc_hd__mux2_2
XFILLER_0_22_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1382_ net37 net48 VGND VGND VPWR VPWR _0502_ sky130_fd_sc_hd__or2_2
X_1451_ _0416_ _0417_ _0419_ _0406_ VGND VGND VPWR VPWR _0571_ sky130_fd_sc_hd__a22oi_4
XFILLER_0_26_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_26_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2003_ net13 _1105_ VGND VGND VPWR VPWR _1106_ sky130_fd_sc_hd__nand2_1
XFILLER_0_9_137 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1649_ _0511_ _0761_ _0764_ _0565_ VGND VGND VPWR VPWR _0765_ sky130_fd_sc_hd__o2bb2a_1
X_1718_ _0769_ _0744_ _0297_ VGND VGND VPWR VPWR _0832_ sky130_fd_sc_hd__mux2_1
XFILLER_0_13_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_8_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_59_305 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_27_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1503_ _0620_ _0621_ VGND VGND VPWR VPWR _0622_ sky130_fd_sc_hd__or2_1
XFILLER_0_2_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1365_ _0146_ _0462_ _0252_ VGND VGND VPWR VPWR _0485_ sky130_fd_sc_hd__a21boi_1
X_1434_ _0293_ VGND VGND VPWR VPWR _0554_ sky130_fd_sc_hd__inv_2
X_1296_ _0406_ _0398_ VGND VGND VPWR VPWR _0416_ sky130_fd_sc_hd__nand2b_2
XFILLER_0_18_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput18 data_in1[21] VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__buf_4
XFILLER_0_49_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_205 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xinput29 data_in1[31] VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__buf_4
XFILLER_0_32_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1150_ net35 net67 VGND VGND VPWR VPWR _0103_ sky130_fd_sc_hd__or2_1
XFILLER_0_59_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_7_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_55_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_121 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1983_ _0664_ _1086_ VGND VGND VPWR VPWR _1087_ sky130_fd_sc_hd__and2_1
X_1417_ _0533_ _0536_ _0188_ VGND VGND VPWR VPWR _0537_ sky130_fd_sc_hd__mux2_1
XFILLER_0_23_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_165 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_64_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1348_ _0466_ _0467_ VGND VGND VPWR VPWR _0468_ sky130_fd_sc_hd__or2_1
X_1279_ net25 VGND VGND VPWR VPWR _0399_ sky130_fd_sc_hd__inv_2
XFILLER_0_46_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_52_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_52_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_49_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2251_ _0399_ _0218_ VGND VGND VPWR VPWR _0221_ sky130_fd_sc_hd__and2_1
X_2182_ _0535_ _0534_ _0425_ VGND VGND VPWR VPWR _0148_ sky130_fd_sc_hd__mux2_1
XFILLER_0_18_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1202_ _0320_ _0321_ VGND VGND VPWR VPWR _0322_ sky130_fd_sc_hd__nand2_1
XFILLER_0_47_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_28_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1966_ _0899_ _1070_ _0552_ VGND VGND VPWR VPWR _1071_ sky130_fd_sc_hd__o21a_1
XFILLER_0_43_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1897_ net40 _1003_ _0667_ VGND VGND VPWR VPWR _1004_ sky130_fd_sc_hd__o21a_1
XFILLER_0_59_93 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_11_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_296 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_38_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_19_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_149 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_29_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1820_ net68 net67 VGND VGND VPWR VPWR _0930_ sky130_fd_sc_hd__or2_1
XFILLER_0_52_163 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_52_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_336 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1751_ _0861_ _0863_ VGND VGND VPWR VPWR _0864_ sky130_fd_sc_hd__xnor2_1
X_1682_ _0299_ _0795_ _0796_ _0302_ VGND VGND VPWR VPWR _0797_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_20_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2234_ net24 net56 _0888_ _0202_ VGND VGND VPWR VPWR _0203_ sky130_fd_sc_hd__a31o_1
X_2303_ _0270_ _0271_ _0274_ VGND VGND VPWR VPWR _0275_ sky130_fd_sc_hd__and3_1
XFILLER_0_45_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2165_ _0742_ _1098_ _0129_ VGND VGND VPWR VPWR _0130_ sky130_fd_sc_hd__a21oi_1
X_2096_ _1090_ _0056_ VGND VGND VPWR VPWR _0057_ sky130_fd_sc_hd__nor2_1
XFILLER_0_43_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1949_ _1052_ _1053_ VGND VGND VPWR VPWR _1054_ sky130_fd_sc_hd__and2b_1
XFILLER_0_3_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_9_95 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_16_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_26_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1803_ _0695_ _0793_ _0913_ VGND VGND VPWR VPWR _0914_ sky130_fd_sc_hd__a21oi_1
X_1734_ _0492_ _0715_ _0846_ _0460_ VGND VGND VPWR VPWR _0847_ sky130_fd_sc_hd__a22o_1
X_1596_ _0711_ _0712_ _0640_ VGND VGND VPWR VPWR _0713_ sky130_fd_sc_hd__mux2_1
X_1665_ _0766_ _0772_ _0776_ _0780_ VGND VGND VPWR VPWR _0781_ sky130_fd_sc_hd__or4_1
XFILLER_0_21_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2217_ net24 _0182_ VGND VGND VPWR VPWR _0184_ sky130_fd_sc_hd__and2_1
XFILLER_0_48_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2148_ net21 _0110_ VGND VGND VPWR VPWR _0111_ sky130_fd_sc_hd__and2_1
X_2079_ _0553_ _0026_ _0038_ _0664_ VGND VGND VPWR VPWR _0039_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_63_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_48_288 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_8_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1450_ _0458_ _0513_ _0549_ _0552_ _0569_ VGND VGND VPWR VPWR _0570_ sky130_fd_sc_hd__a32o_1
XFILLER_0_22_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1381_ _0500_ VGND VGND VPWR VPWR _0501_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_42_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_26_97 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_9_116 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_9_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2002_ net45 _1104_ VGND VGND VPWR VPWR _1105_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_42_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1717_ _0773_ _0830_ _0691_ _0690_ _0469_ _0481_ VGND VGND VPWR VPWR _0831_ sky130_fd_sc_hd__mux4_2
X_1648_ _0460_ _0762_ _0763_ VGND VGND VPWR VPWR _0764_ sky130_fd_sc_hd__a21oi_1
X_1579_ net27 _0695_ _0428_ _0429_ VGND VGND VPWR VPWR _0697_ sky130_fd_sc_hd__a31o_1
XTAP_350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_6_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_13_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_18 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_59_317 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_42_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_27_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_11 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_56_9 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1502_ net35 _0443_ _0498_ VGND VGND VPWR VPWR _0621_ sky130_fd_sc_hd__a21boi_1
X_1433_ _0300_ VGND VGND VPWR VPWR _0553_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1364_ net33 _0462_ _0424_ VGND VGND VPWR VPWR _0484_ sky130_fd_sc_hd__a21oi_1
X_1295_ net4 net3 _0398_ _0406_ VGND VGND VPWR VPWR _0415_ sky130_fd_sc_hd__and4b_1
XFILLER_0_53_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_261 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_33_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_49_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xinput19 data_in1[22] VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_24_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_20_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1982_ _1077_ _1084_ VGND VGND VPWR VPWR _1086_ sky130_fd_sc_hd__or2_1
XFILLER_0_23_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_2_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1416_ _0534_ _0535_ _0252_ VGND VGND VPWR VPWR _0536_ sky130_fd_sc_hd__mux2_1
X_1347_ net36 _0462_ _0252_ VGND VGND VPWR VPWR _0467_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_2_177 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1278_ net2 VGND VGND VPWR VPWR _0398_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_14_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_342 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_64_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_52_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2250_ _0399_ _0218_ VGND VGND VPWR VPWR _0219_ sky130_fd_sc_hd__nor2_1
X_1201_ net11 net43 VGND VGND VPWR VPWR _0321_ sky130_fd_sc_hd__nand2_1
X_2181_ _0011_ _0049_ _0469_ VGND VGND VPWR VPWR _0147_ sky130_fd_sc_hd__mux2_1
XFILLER_0_34_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_109 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_55_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_47_128 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1965_ _0884_ net29 _0566_ _1060_ VGND VGND VPWR VPWR _1070_ sky130_fd_sc_hd__o22a_1
XFILLER_0_7_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1896_ net121 net103 net124 VGND VGND VPWR VPWR _1003_ sky130_fd_sc_hd__or3_4
XFILLER_0_38_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_52_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_183 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1750_ _0814_ _0816_ _0862_ VGND VGND VPWR VPWR _0863_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_29_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_52_175 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_40_348 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1681_ _0744_ VGND VGND VPWR VPWR _0796_ sky130_fd_sc_hd__clkbuf_4
X_2164_ _0493_ _0126_ _0128_ _0501_ _0891_ VGND VGND VPWR VPWR _0129_ sky130_fd_sc_hd__a221o_1
XFILLER_0_29_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2233_ net24 net56 _0422_ VGND VGND VPWR VPWR _0202_ sky130_fd_sc_hd__a21oi_1
X_2302_ _0350_ _0273_ VGND VGND VPWR VPWR _0274_ sky130_fd_sc_hd__xor2_1
XFILLER_0_61_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2095_ net18 net50 _0865_ _0055_ VGND VGND VPWR VPWR _0056_ sky130_fd_sc_hd__o22a_1
XFILLER_0_35_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1879_ _0979_ _0985_ VGND VGND VPWR VPWR _0987_ sky130_fd_sc_hd__nand2_1
XFILLER_0_16_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_16_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1948_ net11 _1050_ _1051_ VGND VGND VPWR VPWR _1053_ sky130_fd_sc_hd__nand3b_1
XFILLER_0_3_261 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_26_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1802_ _0545_ _0912_ VGND VGND VPWR VPWR _0913_ sky130_fd_sc_hd__and2b_1
X_1733_ _0716_ _0711_ _0480_ VGND VGND VPWR VPWR _0846_ sky130_fd_sc_hd__mux2_1
XFILLER_0_25_175 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_25_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1595_ _0584_ _0597_ _0504_ VGND VGND VPWR VPWR _0712_ sky130_fd_sc_hd__mux2_1
XTAP_543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1664_ _0699_ _0764_ _0779_ _0457_ VGND VGND VPWR VPWR _0780_ sky130_fd_sc_hd__o211a_1
XFILLER_0_0_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2147_ net53 _0109_ VGND VGND VPWR VPWR _0110_ sky130_fd_sc_hd__xnor2_1
X_2216_ net24 _0182_ VGND VGND VPWR VPWR _0183_ sky130_fd_sc_hd__nor2_1
XFILLER_0_15_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_63_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2078_ _0029_ _0037_ VGND VGND VPWR VPWR _0038_ sky130_fd_sc_hd__xor2_1
XFILLER_0_16_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_39_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1380_ net62 _0479_ VGND VGND VPWR VPWR _0500_ sky130_fd_sc_hd__nor2_2
XFILLER_0_10_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2001_ net44 net116 _0922_ VGND VGND VPWR VPWR _1104_ sky130_fd_sc_hd__o21a_1
XFILLER_0_45_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_26_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1716_ _0484_ _0489_ VGND VGND VPWR VPWR _0830_ sky130_fd_sc_hd__or2_1
XFILLER_0_45_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1647_ _0470_ _0492_ _0501_ _0491_ VGND VGND VPWR VPWR _0763_ sky130_fd_sc_hd__a22o_1
X_1578_ net27 _0695_ _0422_ VGND VGND VPWR VPWR _0696_ sky130_fd_sc_hd__a21oi_1
XTAP_384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_6_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer20 net119 VGND VGND VPWR VPWR net120 sky130_fd_sc_hd__clkbuf_1
XPHY_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_226 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_59_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1501_ _0146_ _0443_ _0582_ VGND VGND VPWR VPWR _0620_ sky130_fd_sc_hd__a21oi_1
X_1363_ _0461_ _0482_ VGND VGND VPWR VPWR _0483_ sky130_fd_sc_hd__nand2_1
X_1432_ _0551_ VGND VGND VPWR VPWR _0552_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_53_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1294_ _0405_ _0412_ _0413_ VGND VGND VPWR VPWR _0414_ sky130_fd_sc_hd__nor3b_1
XFILLER_0_41_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_64_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1981_ _1077_ _1084_ VGND VGND VPWR VPWR _1085_ sky130_fd_sc_hd__nand2_1
XFILLER_0_2_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1415_ net22 _0487_ VGND VGND VPWR VPWR _0535_ sky130_fd_sc_hd__nand2_1
X_1346_ net35 _0462_ _0424_ VGND VGND VPWR VPWR _0466_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_48_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_48_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_64_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1277_ _0370_ net61 _0354_ _0396_ VGND VGND VPWR VPWR _0397_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_61_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_46_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_52_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_354 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_64_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2180_ net22 net54 _0865_ _0144_ VGND VGND VPWR VPWR _0145_ sky130_fd_sc_hd__o22a_1
XFILLER_0_18_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1200_ net11 net43 VGND VGND VPWR VPWR _0320_ sky130_fd_sc_hd__or2_1
XFILLER_0_34_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_28_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1964_ _0458_ _1058_ _1061_ _1068_ VGND VGND VPWR VPWR _1069_ sky130_fd_sc_hd__a31o_1
X_1895_ _0664_ _0986_ _0987_ _0991_ _1002_ VGND VGND VPWR VPWR net72 sky130_fd_sc_hd__a311o_1
XFILLER_0_11_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1329_ _0446_ _0448_ VGND VGND VPWR VPWR _0449_ sky130_fd_sc_hd__or2_1
XFILLER_0_38_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_21 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1680_ _0301_ _0770_ _0767_ VGND VGND VPWR VPWR _0795_ sky130_fd_sc_hd__o21ai_1
X_2301_ net60 _0432_ _0159_ _0042_ VGND VGND VPWR VPWR _0273_ sky130_fd_sc_hd__o31a_1
X_2163_ _0069_ _0127_ _0504_ VGND VGND VPWR VPWR _0128_ sky130_fd_sc_hd__mux2_1
X_2232_ _0197_ _0200_ _0899_ VGND VGND VPWR VPWR _0201_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_0_44 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2094_ net18 net50 _0888_ _0054_ VGND VGND VPWR VPWR _0055_ sky130_fd_sc_hd__a31o_1
XFILLER_0_43_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1878_ _0979_ _0985_ VGND VGND VPWR VPWR _0986_ sky130_fd_sc_hd__or2_1
XFILLER_0_16_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1947_ _1050_ _1051_ net11 VGND VGND VPWR VPWR _1052_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_3_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1801_ _0851_ _0911_ _0505_ VGND VGND VPWR VPWR _0912_ sky130_fd_sc_hd__mux2_1
X_1732_ _0841_ _0842_ _0844_ VGND VGND VPWR VPWR _0845_ sky130_fd_sc_hd__a21oi_1
X_1663_ _0514_ _0778_ VGND VGND VPWR VPWR _0779_ sky130_fd_sc_hd__nand2_1
XFILLER_0_31_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_187 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_25_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_305 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_13_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1594_ _0600_ _0591_ _0504_ VGND VGND VPWR VPWR _0711_ sky130_fd_sc_hd__mux2_1
XTAP_533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2146_ _0434_ _0042_ _0027_ VGND VGND VPWR VPWR _0109_ sky130_fd_sc_hd__a21o_1
X_2215_ net56 _0181_ VGND VGND VPWR VPWR _0182_ sky130_fd_sc_hd__xnor2_1
X_2077_ _1084_ _0032_ _0036_ VGND VGND VPWR VPWR _0037_ sky130_fd_sc_hd__o21a_1
XFILLER_0_8_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_8_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_31_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_39_268 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_54_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2000_ _1085_ _1087_ _1094_ _1103_ VGND VGND VPWR VPWR net76 sky130_fd_sc_hd__a211o_1
XFILLER_0_42_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1646_ _0478_ _0522_ _0560_ VGND VGND VPWR VPWR _0762_ sky130_fd_sc_hd__mux2_1
X_1715_ _0553_ _0828_ _0551_ VGND VGND VPWR VPWR _0829_ sky130_fd_sc_hd__o21a_1
XFILLER_0_5_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1577_ _0640_ VGND VGND VPWR VPWR _0695_ sky130_fd_sc_hd__clkbuf_4
XTAP_396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2129_ _0695_ _0012_ _0090_ VGND VGND VPWR VPWR _0091_ sky130_fd_sc_hd__a21oi_1
XPHY_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xrebuffer21 _0435_ VGND VGND VPWR VPWR net121 sky130_fd_sc_hd__clkbuf_2
Xrebuffer10 _0975_ VGND VGND VPWR VPWR net110 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_36_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1500_ _0611_ _0618_ _0560_ VGND VGND VPWR VPWR _0619_ sky130_fd_sc_hd__mux2_1
XFILLER_0_35_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1362_ _0470_ _0478_ _0481_ VGND VGND VPWR VPWR _0482_ sky130_fd_sc_hd__mux2_1
X_1431_ _0300_ _0370_ _0550_ VGND VGND VPWR VPWR _0551_ sky130_fd_sc_hd__a21oi_4
XFILLER_0_10_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1293_ _0369_ _0397_ _0398_ _0350_ VGND VGND VPWR VPWR _0413_ sky130_fd_sc_hd__a211o_1
Xoutput90 net90 VGND VGND VPWR VPWR data_out[29] sky130_fd_sc_hd__buf_6
XFILLER_0_58_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1629_ net30 _0461_ _0428_ _0745_ _0429_ VGND VGND VPWR VPWR _0746_ sky130_fd_sc_hd__a311o_1
XFILLER_0_5_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_59_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1980_ _1080_ _1081_ _1083_ VGND VGND VPWR VPWR _1084_ sky130_fd_sc_hd__and3_1
Xrebuffer1 _0104_ VGND VGND VPWR VPWR net101 sky130_fd_sc_hd__buf_1
X_1414_ net21 _0487_ VGND VGND VPWR VPWR _0534_ sky130_fd_sc_hd__nand2_1
X_1345_ _0463_ _0464_ VGND VGND VPWR VPWR _0465_ sky130_fd_sc_hd__or2_1
XFILLER_0_48_97 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_48_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_3_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1276_ net24 _0371_ _0366_ _0389_ _0395_ VGND VGND VPWR VPWR _0396_ sky130_fd_sc_hd__o221a_1
XFILLER_0_46_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_46_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_14_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_366 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_37_311 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_55_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_130 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_50_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1894_ _0898_ _0456_ _0995_ _1001_ VGND VGND VPWR VPWR _1002_ sky130_fd_sc_hd__o31ai_1
X_1963_ _0891_ _1065_ _1067_ VGND VGND VPWR VPWR _1068_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_51_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1328_ _0447_ VGND VGND VPWR VPWR _0448_ sky130_fd_sc_hd__clkbuf_4
X_1259_ _0360_ _0378_ VGND VGND VPWR VPWR _0379_ sky130_fd_sc_hd__or2_1
XFILLER_0_61_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_347 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_6_260 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_40_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_380 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2231_ _0724_ _0456_ _0962_ _0964_ _0198_ VGND VGND VPWR VPWR _0200_ sky130_fd_sc_hd__o32a_1
XFILLER_0_29_33 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2300_ _0352_ _0234_ _0256_ net106 _0255_ VGND VGND VPWR VPWR _0271_ sky130_fd_sc_hd__o221ai_4
XFILLER_0_20_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2162_ _0534_ _0523_ _0582_ VGND VGND VPWR VPWR _0127_ sky130_fd_sc_hd__mux2_1
XFILLER_0_45_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2093_ net18 net50 _0422_ VGND VGND VPWR VPWR _0054_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_28_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1877_ _0881_ _0981_ _0984_ VGND VGND VPWR VPWR _0985_ sky130_fd_sc_hd__o21bai_2
XFILLER_0_9_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1946_ _1049_ _0667_ net108 net43 VGND VGND VPWR VPWR _1051_ sky130_fd_sc_hd__a211o_1
XFILLER_0_15_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1800_ _0608_ _0621_ VGND VGND VPWR VPWR _0911_ sky130_fd_sc_hd__or2_1
X_1731_ _0460_ _0843_ VGND VGND VPWR VPWR _0844_ sky130_fd_sc_hd__nor2_1
X_1662_ _0290_ _0640_ _0544_ _0777_ VGND VGND VPWR VPWR _0778_ sky130_fd_sc_hd__o31a_1
XFILLER_0_40_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_25_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_317 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1593_ _0706_ _0707_ _0709_ VGND VGND VPWR VPWR _0710_ sky130_fd_sc_hd__a21oi_1
X_2214_ net55 _0159_ _0042_ VGND VGND VPWR VPWR _0181_ sky130_fd_sc_hd__o21a_1
XFILLER_0_21_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2145_ _0036_ _0102_ _0106_ _0107_ VGND VGND VPWR VPWR _0108_ sky130_fd_sc_hd__o211a_1
X_2076_ _0033_ net112 _0034_ _0035_ VGND VGND VPWR VPWR _0036_ sky130_fd_sc_hd__a22oi_2
X_1929_ _0555_ _0824_ VGND VGND VPWR VPWR _1035_ sky130_fd_sc_hd__or2_1
XFILLER_0_8_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_8_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_16_122 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_31_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_60_209 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_38_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_261 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1576_ _0649_ _0693_ VGND VGND VPWR VPWR _0694_ sky130_fd_sc_hd__nor2_1
X_1645_ _0290_ _0759_ _0760_ _0603_ VGND VGND VPWR VPWR _0761_ sky130_fd_sc_hd__a2bb2o_1
X_1714_ _0511_ _0823_ _0827_ _0566_ VGND VGND VPWR VPWR _0828_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_13_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xrebuffer11 _0975_ VGND VGND VPWR VPWR net125 sky130_fd_sc_hd__dlymetal6s2s_1
X_2128_ _0640_ _0089_ VGND VGND VPWR VPWR _0090_ sky130_fd_sc_hd__and2b_1
XPHY_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2059_ _0727_ _1120_ _0009_ _0017_ VGND VGND VPWR VPWR _0018_ sky130_fd_sc_hd__o211a_1
XPHY_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xrebuffer22 net121 VGND VGND VPWR VPWR net122 sky130_fd_sc_hd__clkbuf_1
XPHY_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1430_ net3 net4 _0406_ _0398_ VGND VGND VPWR VPWR _0550_ sky130_fd_sc_hd__nand4b_4
X_1361_ _0480_ VGND VGND VPWR VPWR _0481_ sky130_fd_sc_hd__clkbuf_4
Xoutput91 net91 VGND VGND VPWR VPWR data_out[2] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_37_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1292_ _0406_ net4 _0411_ net3 VGND VGND VPWR VPWR _0412_ sky130_fd_sc_hd__or4b_1
Xoutput80 net80 VGND VGND VPWR VPWR data_out[1] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_41_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1559_ _0528_ _0518_ _0188_ VGND VGND VPWR VPWR _0677_ sky130_fd_sc_hd__mux2_1
X_1628_ net30 _0461_ _0744_ VGND VGND VPWR VPWR _0745_ sky130_fd_sc_hd__a21oi_1
XTAP_150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xrebuffer2 net101 VGND VGND VPWR VPWR net102 sky130_fd_sc_hd__clkbuf_1
X_1413_ _0531_ _0532_ _0252_ VGND VGND VPWR VPWR _0533_ sky130_fd_sc_hd__mux2_1
XFILLER_0_48_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1344_ net7 _0462_ _0252_ VGND VGND VPWR VPWR _0464_ sky130_fd_sc_hd__a21boi_1
X_1275_ _0362_ _0394_ VGND VGND VPWR VPWR _0395_ sky130_fd_sc_hd__nand2_1
XFILLER_0_46_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_61_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_46_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_14_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_64_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_37_378 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_37_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_142 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1962_ _0768_ _1066_ _0320_ VGND VGND VPWR VPWR _1067_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_59_31 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_43_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_28_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1893_ _0891_ _0998_ _1000_ VGND VGND VPWR VPWR _1001_ sky130_fd_sc_hd__o21a_1
XFILLER_0_11_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1327_ net64 net63 VGND VGND VPWR VPWR _0447_ sky130_fd_sc_hd__or2_1
X_1258_ net13 _0376_ net12 _0377_ VGND VGND VPWR VPWR _0378_ sky130_fd_sc_hd__o22a_1
X_1189_ net33 net65 VGND VGND VPWR VPWR _0309_ sky130_fd_sc_hd__and2b_1
XFILLER_0_34_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_61_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_272 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_37_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_25_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_209 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2230_ _0554_ _1088_ VGND VGND VPWR VPWR _0198_ sky130_fd_sc_hd__nand2_1
XFILLER_0_29_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2161_ _1136_ _0022_ _0626_ VGND VGND VPWR VPWR _0126_ sky130_fd_sc_hd__mux2_1
XFILLER_0_45_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2092_ _0743_ _0898_ _0794_ _0448_ VGND VGND VPWR VPWR _0053_ sky130_fd_sc_hd__o31a_1
XFILLER_0_28_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1945_ _1049_ _1003_ _0922_ net43 VGND VGND VPWR VPWR _1050_ sky130_fd_sc_hd__o211ai_1
X_1876_ _0925_ _0982_ _0980_ _0983_ _0957_ VGND VGND VPWR VPWR _0984_ sky130_fd_sc_hd__a32o_1
XFILLER_0_9_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_31_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1730_ _0712_ _0708_ _0560_ VGND VGND VPWR VPWR _0843_ sky130_fd_sc_hd__mux2_1
X_1592_ _0545_ _0708_ VGND VGND VPWR VPWR _0709_ sky130_fd_sc_hd__nor2_1
X_1661_ net62 _0760_ VGND VGND VPWR VPWR _0777_ sky130_fd_sc_hd__or2_1
XFILLER_0_40_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_212 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_13_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_56_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2213_ _0665_ _0165_ _0180_ VGND VGND VPWR VPWR net87 sky130_fd_sc_hd__a21o_1
X_2144_ net20 _0081_ VGND VGND VPWR VPWR _0107_ sky130_fd_sc_hd__nand2_1
XFILLER_0_8_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2075_ _0001_ net126 VGND VGND VPWR VPWR _0035_ sky130_fd_sc_hd__nand2_1
X_1928_ _0743_ _0820_ _0842_ VGND VGND VPWR VPWR _1034_ sky130_fd_sc_hd__o21ai_1
X_1859_ _0768_ _0967_ VGND VGND VPWR VPWR _0968_ sky130_fd_sc_hd__nand2_1
XFILLER_0_8_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_8_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_47_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_62_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1713_ _0826_ VGND VGND VPWR VPWR _0827_ sky130_fd_sc_hd__inv_2
XFILLER_0_45_229 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_5_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_13_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1644_ _0529_ _0537_ _0479_ VGND VGND VPWR VPWR _0760_ sky130_fd_sc_hd__mux2_1
X_1575_ _0640_ _0692_ VGND VGND VPWR VPWR _0693_ sky130_fd_sc_hd__or2_1
XTAP_332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2127_ _0049_ _0088_ _0469_ VGND VGND VPWR VPWR _0089_ sky130_fd_sc_hd__mux2_1
XTAP_398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xrebuffer12 _0031_ VGND VGND VPWR VPWR net112 sky130_fd_sc_hd__clkbuf_1
Xrebuffer23 _1024_ VGND VGND VPWR VPWR net123 sky130_fd_sc_hd__clkbuf_1
X_2058_ _1101_ _0015_ _0016_ _0714_ _1118_ VGND VGND VPWR VPWR _0017_ sky130_fd_sc_hd__o32a_1
XPHY_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_276 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_50_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1360_ _0479_ VGND VGND VPWR VPWR _0480_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_2_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput70 net70 VGND VGND VPWR VPWR data_out[10] sky130_fd_sc_hd__clkbuf_4
Xoutput81 net81 VGND VGND VPWR VPWR data_out[20] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_37_12 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1291_ _0368_ _0407_ _0409_ _0410_ VGND VGND VPWR VPWR _0411_ sky130_fd_sc_hd__and4_1
Xoutput92 net92 VGND VGND VPWR VPWR data_out[30] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_58_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_58_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_53_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1489_ net36 _0443_ _0582_ VGND VGND VPWR VPWR _0608_ sky130_fd_sc_hd__a21oi_1
X_1558_ _0560_ _0674_ _0675_ _0586_ VGND VGND VPWR VPWR _0676_ sky130_fd_sc_hd__a22o_1
X_1627_ _0421_ VGND VGND VPWR VPWR _0744_ sky130_fd_sc_hd__clkbuf_4
XTAP_173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_324 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_17_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_55_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xrebuffer3 _0450_ VGND VGND VPWR VPWR net103 sky130_fd_sc_hd__clkbuf_2
X_1412_ net24 _0487_ VGND VGND VPWR VPWR _0532_ sky130_fd_sc_hd__nand2_2
X_1343_ net6 _0462_ _0424_ VGND VGND VPWR VPWR _0463_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_47_9 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_64_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1274_ _0364_ _0392_ _0393_ VGND VGND VPWR VPWR _0394_ sky130_fd_sc_hd__a21o_1
XFILLER_0_61_305 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_46_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_14_265 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_1_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_64_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1961_ _0770_ _0422_ _0321_ VGND VGND VPWR VPWR _1066_ sky130_fd_sc_hd__mux2_1
X_1892_ _0327_ _0999_ _0796_ _0329_ VGND VGND VPWR VPWR _1000_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_59_43 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_51_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_11_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1326_ _0445_ VGND VGND VPWR VPWR _0446_ sky130_fd_sc_hd__buf_2
X_1188_ _0306_ _0293_ _0302_ _0307_ VGND VGND VPWR VPWR _0308_ sky130_fd_sc_hd__a31o_1
X_1257_ _0358_ _0359_ net44 VGND VGND VPWR VPWR _0377_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_61_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_6_284 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_19_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_146 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_33_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_25_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_20_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2160_ net21 net53 _0429_ _0123_ VGND VGND VPWR VPWR _0124_ sky130_fd_sc_hd__o22a_1
XFILLER_0_29_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2091_ _1014_ _0010_ _0050_ _0014_ _1101_ VGND VGND VPWR VPWR _0052_ sky130_fd_sc_hd__a221o_1
XFILLER_0_61_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1875_ _0952_ _0956_ VGND VGND VPWR VPWR _0983_ sky130_fd_sc_hd__nand2_1
X_1944_ net42 net41 net40 VGND VGND VPWR VPWR _1049_ sky130_fd_sc_hd__or3_1
XFILLER_0_10_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1309_ _0398_ _0406_ _0418_ VGND VGND VPWR VPWR _0429_ sky130_fd_sc_hd__nor3_4
X_2289_ net28 net60 _0888_ _0259_ VGND VGND VPWR VPWR _0260_ sky130_fd_sc_hd__a31o_1
XFILLER_0_19_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_319 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_30_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_31_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_25_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1591_ _0576_ _0583_ _0504_ VGND VGND VPWR VPWR _0708_ sky130_fd_sc_hd__mux2_1
XTAP_525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1660_ _0649_ _0775_ VGND VGND VPWR VPWR _0776_ sky130_fd_sc_hd__nor2_1
XFILLER_0_0_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_99 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_56_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2212_ _0176_ _0179_ VGND VGND VPWR VPWR _0180_ sky130_fd_sc_hd__or2_1
X_2143_ _0064_ _0063_ _0065_ _0083_ _0105_ VGND VGND VPWR VPWR _0106_ sky130_fd_sc_hd__o41a_1
XFILLER_0_63_208 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_48_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2074_ _0001_ net126 _0000_ VGND VGND VPWR VPWR _0034_ sky130_fd_sc_hd__o21ai_1
X_1858_ _0770_ _0422_ _0041_ VGND VGND VPWR VPWR _0967_ sky130_fd_sc_hd__mux2_1
XFILLER_0_8_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1927_ net113 _1032_ VGND VGND VPWR VPWR _1033_ sky130_fd_sc_hd__xor2_1
X_1789_ _0514_ _0564_ VGND VGND VPWR VPWR _0901_ sky130_fd_sc_hd__nor2_1
XFILLER_0_12_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_22_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_1 _0749_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_230 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1712_ _0500_ _0684_ _0824_ _0459_ _0825_ VGND VGND VPWR VPWR _0826_ sky130_fd_sc_hd__a221o_1
X_1643_ _0559_ _0706_ _0707_ VGND VGND VPWR VPWR _0759_ sky130_fd_sc_hd__o21a_1
XFILLER_0_5_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_5_305 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1574_ _0690_ _0691_ _0496_ VGND VGND VPWR VPWR _0692_ sky130_fd_sc_hd__mux2_1
XTAP_366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2126_ _0596_ _0599_ VGND VGND VPWR VPWR _0088_ sky130_fd_sc_hd__or2_1
XTAP_399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2057_ _0742_ _0300_ _0741_ _0448_ VGND VGND VPWR VPWR _0016_ sky130_fd_sc_hd__o31a_1
XTAP_388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer13 _1028_ VGND VGND VPWR VPWR net113 sky130_fd_sc_hd__clkbuf_1
Xrebuffer24 _0871_ VGND VGND VPWR VPWR net124 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_36_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput93 net93 VGND VGND VPWR VPWR data_out[31] sky130_fd_sc_hd__clkbuf_4
Xoutput82 net82 VGND VGND VPWR VPWR data_out[21] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_50_288 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput71 net71 VGND VGND VPWR VPWR data_out[11] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_37_24 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1290_ _0167_ _0199_ _0231_ _0330_ VGND VGND VPWR VPWR _0410_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_37_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_58_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_41_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1626_ _0742_ VGND VGND VPWR VPWR _0743_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_5_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1557_ _0533_ _0540_ _0495_ VGND VGND VPWR VPWR _0675_ sky130_fd_sc_hd__mux2_1
X_1488_ _0605_ _0606_ VGND VGND VPWR VPWR _0607_ sky130_fd_sc_hd__or2_1
XTAP_174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2109_ _0069_ _0022_ _1136_ _1097_ _0496_ _0481_ VGND VGND VPWR VPWR _0070_ sky130_fd_sc_hd__mux4_1
XFILLER_0_32_233 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_32_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_63_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer4 _0441_ VGND VGND VPWR VPWR net104 sky130_fd_sc_hd__buf_1
XFILLER_0_23_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1411_ net23 _0487_ VGND VGND VPWR VPWR _0531_ sky130_fd_sc_hd__nand2_1
X_1342_ _0441_ VGND VGND VPWR VPWR _0462_ sky130_fd_sc_hd__buf_4
X_1273_ net23 net55 VGND VGND VPWR VPWR _0393_ sky130_fd_sc_hd__and2b_1
XFILLER_0_64_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_61_317 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_13_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1609_ _0695_ _0725_ _0709_ VGND VGND VPWR VPWR _0726_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_1_193 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_14_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_55_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1960_ _0853_ _1064_ _0783_ VGND VGND VPWR VPWR _1065_ sky130_fd_sc_hd__mux2_1
XFILLER_0_28_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1891_ _0328_ _0770_ _0767_ VGND VGND VPWR VPWR _0999_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_59_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1325_ net4 net3 _0416_ VGND VGND VPWR VPWR _0445_ sky130_fd_sc_hd__or3_1
X_1256_ net45 VGND VGND VPWR VPWR _0376_ sky130_fd_sc_hd__inv_2
X_1187_ net32 _0300_ VGND VGND VPWR VPWR _0307_ sky130_fd_sc_hd__and2b_1
XFILLER_0_61_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_61_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_27_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_296 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_52_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2090_ _0049_ _0011_ _1112_ _1062_ _0495_ _0480_ VGND VGND VPWR VPWR _0050_ sky130_fd_sc_hd__mux4_2
XFILLER_0_45_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1943_ _0572_ _1033_ _1038_ _1048_ VGND VGND VPWR VPWR net74 sky130_fd_sc_hd__o22a_1
X_1874_ _0874_ _0926_ VGND VGND VPWR VPWR _0982_ sky130_fd_sc_hd__nand2_1
XFILLER_0_9_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1308_ _0427_ VGND VGND VPWR VPWR _0428_ sky130_fd_sc_hd__clkbuf_4
X_2288_ net28 net60 _0744_ VGND VGND VPWR VPWR _0259_ sky130_fd_sc_hd__a21oi_1
X_1239_ net13 net45 VGND VGND VPWR VPWR _0359_ sky130_fd_sc_hd__nand2_1
XFILLER_0_62_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_57_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_31_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_25_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1590_ _0480_ _0370_ VGND VGND VPWR VPWR _0707_ sky130_fd_sc_hd__nand2_1
XFILLER_0_33_191 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_0_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2211_ _0937_ _1118_ _0177_ VGND VGND VPWR VPWR _0179_ sky130_fd_sc_hd__o21ai_1
X_2142_ net20 _0081_ _0084_ VGND VGND VPWR VPWR _0105_ sky130_fd_sc_hd__o21bai_1
X_2073_ _1075_ _1106_ _1108_ VGND VGND VPWR VPWR _0033_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_56_272 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_44_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1788_ _0562_ _0841_ _0842_ VGND VGND VPWR VPWR _0900_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_31_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1857_ _0899_ _0965_ _0552_ VGND VGND VPWR VPWR _0966_ sky130_fd_sc_hd__o21ai_1
X_1926_ _0979_ _0985_ _1029_ _1031_ VGND VGND VPWR VPWR _1032_ sky130_fd_sc_hd__a31o_1
XFILLER_0_62_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_7_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1711_ _0492_ _0681_ VGND VGND VPWR VPWR _0825_ sky130_fd_sc_hd__and2_1
XFILLER_0_53_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1642_ _0754_ _0756_ VGND VGND VPWR VPWR _0758_ sky130_fd_sc_hd__nand2_1
XFILLER_0_5_317 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1573_ _0426_ _0444_ VGND VGND VPWR VPWR _0691_ sky130_fd_sc_hd__or2_1
XTAP_389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2056_ _0971_ _0010_ _0013_ _0014_ VGND VGND VPWR VPWR _0015_ sky130_fd_sc_hd__a22o_1
X_2125_ _0456_ _0856_ VGND VGND VPWR VPWR _0087_ sky130_fd_sc_hd__or2_1
XPHY_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xrebuffer25 _0003_ VGND VGND VPWR VPWR net126 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer14 _1006_ VGND VGND VPWR VPWR net114 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_44_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_144 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_8_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1909_ _0770_ _0422_ _0324_ VGND VGND VPWR VPWR _1016_ sky130_fd_sc_hd__mux2_1
XFILLER_0_12_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput94 net94 VGND VGND VPWR VPWR data_out[3] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_37_36 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput83 net83 VGND VGND VPWR VPWR data_out[22] sky130_fd_sc_hd__clkbuf_4
Xoutput72 net72 VGND VGND VPWR VPWR data_out[12] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_53_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_58_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_26_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1556_ _0557_ _0577_ _0578_ VGND VGND VPWR VPWR _0674_ sky130_fd_sc_hd__a21o_1
X_1625_ _0555_ VGND VGND VPWR VPWR _0742_ sky130_fd_sc_hd__buf_2
XFILLER_0_41_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1487_ net8 _0506_ _0498_ VGND VGND VPWR VPWR _0606_ sky130_fd_sc_hd__a21boi_1
XTAP_186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2108_ _0524_ _0527_ VGND VGND VPWR VPWR _0069_ sky130_fd_sc_hd__or2_1
X_2039_ _1089_ _1132_ _1135_ _1140_ VGND VGND VPWR VPWR _1141_ sky130_fd_sc_hd__or4b_2
XFILLER_0_64_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_297 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_55_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_23_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1410_ _0522_ _0529_ _0481_ VGND VGND VPWR VPWR _0530_ sky130_fd_sc_hd__mux2_1
XFILLER_0_2_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer5 _0116_ VGND VGND VPWR VPWR net105 sky130_fd_sc_hd__clkbuf_1
X_1341_ _0460_ VGND VGND VPWR VPWR _0461_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_3_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1272_ _0390_ net53 _0365_ _0391_ VGND VGND VPWR VPWR _0392_ sky130_fd_sc_hd__a31o_1
XFILLER_0_61_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1608_ _0502_ _0541_ VGND VGND VPWR VPWR _0725_ sky130_fd_sc_hd__nor2_1
X_1539_ _0408_ _0657_ VGND VGND VPWR VPWR _0658_ sky130_fd_sc_hd__or2_1
XFILLER_0_9_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_43_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1890_ _0775_ _0997_ _0290_ VGND VGND VPWR VPWR _0998_ sky130_fd_sc_hd__mux2_1
XFILLER_0_52_9 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_51_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1324_ net5 _0443_ VGND VGND VPWR VPWR _0444_ sky130_fd_sc_hd__nand2_2
X_1186_ net31 VGND VGND VPWR VPWR _0306_ sky130_fd_sc_hd__inv_2
X_1255_ _0374_ net46 VGND VGND VPWR VPWR _0375_ sky130_fd_sc_hd__nand2_1
XFILLER_0_46_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_61_137 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_6_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_156 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_61_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_28_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1942_ _0664_ _1042_ _1045_ _1047_ VGND VGND VPWR VPWR _1048_ sky130_fd_sc_hd__or4_1
XFILLER_0_0_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1873_ _0876_ _0927_ _0980_ VGND VGND VPWR VPWR _0981_ sky130_fd_sc_hd__or3b_4
XFILLER_0_3_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1169_ net62 VGND VGND VPWR VPWR _0289_ sky130_fd_sc_hd__inv_2
X_1307_ _0416_ _0418_ VGND VGND VPWR VPWR _0427_ sky130_fd_sc_hd__nor2_1
X_2287_ _0255_ _0257_ VGND VGND VPWR VPWR _0258_ sky130_fd_sc_hd__xor2_1
X_1238_ net13 net45 VGND VGND VPWR VPWR _0358_ sky130_fd_sc_hd__or2_1
XFILLER_0_59_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_30_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_30_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_57_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_40_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_25_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2210_ _0884_ _0949_ _0120_ VGND VGND VPWR VPWR _0177_ sky130_fd_sc_hd__or3b_1
XFILLER_0_0_259 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2072_ _1077_ _1107_ _1108_ _0031_ VGND VGND VPWR VPWR _0032_ sky130_fd_sc_hd__or4b_4
X_2141_ _1080_ _1081_ _1083_ _0032_ _0102_ VGND VGND VPWR VPWR _0104_ sky130_fd_sc_hd__a311o_1
XFILLER_0_56_284 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_56_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1925_ net9 _1005_ _1030_ VGND VGND VPWR VPWR _1031_ sky130_fd_sc_hd__o21ba_1
X_1856_ _0901_ _0961_ _0964_ _0515_ VGND VGND VPWR VPWR _0965_ sky130_fd_sc_hd__a22oi_1
X_1787_ _0898_ VGND VGND VPWR VPWR _0899_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_12_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_12_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_39_207 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_1_81 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_62_265 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_62_221 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_22_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_5_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1710_ _0682_ _0677_ _0479_ VGND VGND VPWR VPWR _0824_ sky130_fd_sc_hd__mux2_1
X_1572_ _0498_ _0628_ _0499_ VGND VGND VPWR VPWR _0690_ sky130_fd_sc_hd__o21a_1
XFILLER_0_41_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1641_ _0754_ _0756_ VGND VGND VPWR VPWR _0757_ sky130_fd_sc_hd__or2_1
XFILLER_0_6_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_21_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2124_ _0083_ _0085_ VGND VGND VPWR VPWR _0086_ sky130_fd_sc_hd__xnor2_2
X_2055_ _0459_ _0293_ VGND VGND VPWR VPWR _0014_ sky130_fd_sc_hd__nor2_2
Xrebuffer15 _1006_ VGND VGND VPWR VPWR net115 sky130_fd_sc_hd__clkbuf_1
XPHY_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xrebuffer26 _1003_ VGND VGND VPWR VPWR net127 sky130_fd_sc_hd__dlygate4sd1_1
X_1839_ _0693_ _0948_ _0783_ VGND VGND VPWR VPWR _0949_ sky130_fd_sc_hd__mux2_1
X_1908_ _0794_ _1014_ _0290_ VGND VGND VPWR VPWR _1015_ sky130_fd_sc_hd__mux2_1
XFILLER_0_29_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_23_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput84 net84 VGND VGND VPWR VPWR data_out[23] sky130_fd_sc_hd__clkbuf_4
Xoutput95 net95 VGND VGND VPWR VPWR data_out[4] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_37_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput73 net73 VGND VGND VPWR VPWR data_out[13] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_58_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_126 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1624_ _0695_ _0740_ VGND VGND VPWR VPWR _0741_ sky130_fd_sc_hd__or2_1
XFILLER_0_41_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1555_ _0670_ _0671_ VGND VGND VPWR VPWR _0673_ sky130_fd_sc_hd__nand2_1
XTAP_132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1486_ net7 _0443_ _0582_ VGND VGND VPWR VPWR _0605_ sky130_fd_sc_hd__a21oi_1
XTAP_176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2107_ _0063_ _0067_ VGND VGND VPWR VPWR _0068_ sky130_fd_sc_hd__xor2_1
XTAP_198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2038_ _0884_ _1138_ _0446_ _0300_ _1139_ VGND VGND VPWR VPWR _1140_ sky130_fd_sc_hd__a2111o_1
XFILLER_0_32_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_55_305 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_23_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_63_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1340_ _0459_ VGND VGND VPWR VPWR _0460_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_23_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer6 _0223_ VGND VGND VPWR VPWR net106 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_64_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1271_ net22 net54 VGND VGND VPWR VPWR _0391_ sky130_fd_sc_hd__and2b_1
XFILLER_0_58_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_224 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1469_ _0487_ VGND VGND VPWR VPWR _0588_ sky130_fd_sc_hd__clkbuf_4
X_1538_ _0655_ _0656_ VGND VGND VPWR VPWR _0657_ sky130_fd_sc_hd__and2b_1
X_1607_ _0699_ VGND VGND VPWR VPWR _0724_ sky130_fd_sc_hd__buf_2
XFILLER_0_38_91 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_64_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_59_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1323_ _0442_ VGND VGND VPWR VPWR _0443_ sky130_fd_sc_hd__buf_4
XFILLER_0_51_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1185_ _0294_ _0295_ _0303_ _0304_ VGND VGND VPWR VPWR _0305_ sky130_fd_sc_hd__a211o_1
X_1254_ net14 VGND VGND VPWR VPWR _0374_ sky130_fd_sc_hd__inv_2
XFILLER_0_61_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_93 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_19_305 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_19_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_61_149 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_42_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_319 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_20_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_45_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_61_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1941_ _0699_ _1036_ _1046_ _0457_ VGND VGND VPWR VPWR _1047_ sky130_fd_sc_hd__o211a_1
X_1872_ _0933_ _0956_ _0957_ VGND VGND VPWR VPWR _0980_ sky130_fd_sc_hd__and3_1
XFILLER_0_9_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_51_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1306_ _0425_ VGND VGND VPWR VPWR _0426_ sky130_fd_sc_hd__clkbuf_4
X_2286_ _0352_ _0234_ _0256_ _0223_ VGND VGND VPWR VPWR _0257_ sky130_fd_sc_hd__o22a_1
XFILLER_0_19_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1168_ net16 _0188_ _0199_ _0272_ _0283_ VGND VGND VPWR VPWR _0288_ sky130_fd_sc_hd__o311a_1
X_1237_ net15 net47 VGND VGND VPWR VPWR _0357_ sky130_fd_sc_hd__nand2_1
XFILLER_0_19_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_59_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_34_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_182 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_30_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_15_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2140_ _0045_ _0101_ VGND VGND VPWR VPWR _0102_ sky130_fd_sc_hd__nand2_1
X_2071_ _1128_ _0004_ VGND VGND VPWR VPWR _0031_ sky130_fd_sc_hd__nor2_1
XFILLER_0_56_296 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1855_ _0905_ _0710_ _0842_ VGND VGND VPWR VPWR _0964_ sky130_fd_sc_hd__a21bo_1
X_1924_ net9 _1005_ _0977_ VGND VGND VPWR VPWR _1030_ sky130_fd_sc_hd__a21boi_1
X_1786_ _0553_ VGND VGND VPWR VPWR _0898_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_12_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_12_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2269_ _0574_ _0581_ _0426_ VGND VGND VPWR VPWR _0239_ sky130_fd_sc_hd__mux2_1
XFILLER_0_47_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_93 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_62_277 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_62_233 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_7_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_42_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1640_ _0670_ _0671_ _0735_ _0755_ VGND VGND VPWR VPWR _0756_ sky130_fd_sc_hd__a31o_1
X_1571_ _0300_ _0688_ _0551_ VGND VGND VPWR VPWR _0689_ sky130_fd_sc_hd__o21a_1
XTAP_314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2123_ _0064_ _0063_ _0066_ _0084_ VGND VGND VPWR VPWR _0085_ sky130_fd_sc_hd__o31a_1
Xrebuffer16 _1072_ VGND VGND VPWR VPWR net116 sky130_fd_sc_hd__buf_1
X_2054_ _0012_ _1063_ _0545_ VGND VGND VPWR VPWR _0013_ sky130_fd_sc_hd__mux2_1
XFILLER_0_8_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1907_ _1013_ _0969_ _0911_ _0851_ _0495_ _0480_ VGND VGND VPWR VPWR _1014_ sky130_fd_sc_hd__mux4_1
X_1838_ _0947_ _0892_ _0830_ _0773_ _0495_ _0560_ VGND VGND VPWR VPWR _0948_ sky130_fd_sc_hd__mux4_1
XFILLER_0_32_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1769_ _0756_ _0807_ _0877_ _0879_ _0880_ VGND VGND VPWR VPWR _0881_ sky130_fd_sc_hd__a311oi_4
XFILLER_0_35_211 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_35_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput96 net96 VGND VGND VPWR VPWR data_out[5] sky130_fd_sc_hd__clkbuf_4
Xoutput85 net85 VGND VGND VPWR VPWR data_out[24] sky130_fd_sc_hd__buf_2
Xoutput74 net74 VGND VGND VPWR VPWR data_out[14] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_58_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_41_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_138 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_5_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1623_ _0645_ _0739_ _0505_ VGND VGND VPWR VPWR _0740_ sky130_fd_sc_hd__mux2_1
X_1485_ _0460_ _0587_ _0602_ _0603_ VGND VGND VPWR VPWR _0604_ sky130_fd_sc_hd__a22o_1
X_1554_ _0670_ _0671_ VGND VGND VPWR VPWR _0672_ sky130_fd_sc_hd__or2_1
XTAP_166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
.ends
