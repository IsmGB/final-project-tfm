.SUBCKT sky130_fd_sc_hd__a2bb2o_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
MMIN2 X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNnor0 inor A1_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNnor1 inor A2_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi10 VGND B1 sndNB1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi11 sndNB1 B2 y VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi20 y inor VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi20 y inor pmid VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnor0 VPWR A1_N sndPA1N VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnor1 sndPA1N A2_N inor VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi10 pmid B1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi11 pmid B2 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a2bb2o_2 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
MMIN2 X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNnor0 inor A1_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNnor1 inor A2_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi10 VGND B1 sndNB1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi11 sndNB1 B2 y VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi20 y inor VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi20 y inor pmid VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnor0 VPWR A1_N sndPA1N VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnor1 sndPA1N A2_N inor VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi10 pmid B1 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi11 pmid B2 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a2bb2o_4 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
MMIN2 X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNnor0 inor A1_N VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNnor1 inor A2_N VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi10 VGND B1 sndNB1 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi11 sndNB1 B2 y VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi20 y inor VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi20 y inor pmid VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnor0 VPWR A1_N sndPA1N VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnor1 sndPA1N A2_N inor VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi10 pmid B1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi11 pmid B2 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a2bb2oi_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR Y
MMNnor0 inor A1_N VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNnor1 inor A2_N VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi10 VGND B1 sndNB1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi11 sndNB1 B2 Y VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi20 Y inor VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnor0 VPWR A1_N sndPA1N VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnor1 sndPA1N A2_N inor VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi10 pmid B1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi11 pmid B2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi20 Y inor pmid VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a2bb2oi_2 A1_N A2_N B1 B2 VGND VNB VPB VPWR Y
MMNnor0 inor A1_N VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNnor1 inor A2_N VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi10 VGND B1 sndNB1 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi11 sndNB1 B2 Y VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi20 Y inor VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnor0 VPWR A1_N sndPA1N VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnor1 sndPA1N A2_N inor VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi10 pmid B1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi11 pmid B2 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi20 Y inor pmid VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a2bb2oi_4 A1_N A2_N B1 B2 VGND VNB VPB VPWR Y
MMNnor0 inor A1_N VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNnor1 inor A2_N VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi10 VGND B1 sndNB1 VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi11 sndNB1 B2 Y VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi20 Y inor VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnor0 VPWR A1_N sndPA1N VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnor1 sndPA1N A2_N inor VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi10 pmid B1 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi11 pmid B2 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi20 Y inor pmid VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a21bo_1 A1 A2 B1_N VGND VNB VPB VPWR X
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 y B1 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPB1N B1 B1_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 y A1 sndA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINB1N B1 B1_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a21bo_2 A1 A2 B1_N VGND VNB VPB VPWR X
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 y B1 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPB1N B1 B1_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 y A1 sndA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINB1N B1 B1_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a21bo_4 A1 A2 B1_N VGND VNB VPB VPWR X
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 y B1 pndA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPB1N B1 B1_N VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 y A1 sndA1 VNB nfet_01v8 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA20 y A1 snd2A1 VNB nfet_01v8 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA21 snd2A1 A2 VGND VNB nfet_01v8 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINB1N B1 B1_N VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a21boi_0 A1 A2 B1_N VGND VNB VPB VPWR Y
MMPA0 net40 A1 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 net40 A2 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 Y B1 net40 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPB1N B1 B1_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINB1N B1 B1_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a21boi_1 A1 A2 B1_N VGND VNB VPB VPWR Y
MMPA0 net40 A1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 net40 A2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 Y B1 net40 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPB1N B1 B1_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINB1N B1 B1_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a21boi_2 A1 A2 B1_N VGND VNB VPB VPWR Y
MMPA0 net40 A1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 net40 A2 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 Y B1 net40 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPB1N B1 B1_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINB1N B1 B1_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a21boi_4 A1 A2 B1_N VGND VNB VPB VPWR Y
MMPA0 net40 A1 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 net40 A2 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 Y B1 net40 VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPB1N B1 B1_N VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINB1N B1 B1_N VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 y B1 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 y A1 sndA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a21o_2 A1 A2 B1 VGND VNB VPB VPWR X
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 y B1 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 y A1 sndA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a21o_4 A1 A2 B1 VGND VNB VPB VPWR X
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 y B1 pndA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 y A1 sndA1 VNB nfet_01v8 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA20 y A1 snd2A1 VNB nfet_01v8 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA21 snd2A1 A2 VGND VNB nfet_01v8 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 Y B1 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a21oi_2 A1 A2 B1 VGND VNB VPB VPWR Y
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 Y B1 pndA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a21oi_4 A1 A2 B1 VGND VNB VPB VPWR Y
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 Y B1 pndA VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 y B1 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 y B2 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 y A1 sndA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 sndB1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 sndB1 B2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a22o_2 A1 A2 B1 B2 VGND VNB VPB VPWR X
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 y B1 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 y B2 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 y A1 sndA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 sndB1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 sndB1 B2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a22o_4 A1 A2 B1 B2 VGND VNB VPB VPWR X
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 y B1 pndA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 y B2 pndA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 y A1 sndA1 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 sndB1 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 sndB1 B2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a22oi_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 Y B1 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 Y B2 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 sndB1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 sndB1 B2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a22oi_2 A1 A2 B1 B2 VGND VNB VPB VPWR Y
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 Y B1 pndA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 Y B2 pndA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 sndB1 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 sndB1 B2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a22oi_4 A1 A2 B1 B2 VGND VNB VPB VPWR Y
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 Y B1 pndA VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 Y B2 pndA VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 sndB1 VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 sndB1 B2 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 pndA A3 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 y B1 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 y A1 sndA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 sndA2 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 sndA2 A3 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a31o_2 A1 A2 A3 B1 VGND VNB VPB VPWR X
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 pndA A3 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 y B1 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 y A1 sndA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 sndA2 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 sndA2 A3 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a31o_4 A1 A2 A3 B1 VGND VNB VPB VPWR X
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 pndA A3 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 y B1 pndA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 y A1 sndA1 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 sndA2 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 sndA2 A3 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a31oi_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 pndA A3 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 Y B1 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 sndA2 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 sndA2 A3 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a31oi_2 A1 A2 A3 B1 VGND VNB VPB VPWR Y
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 pndA A3 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 Y B1 pndA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 sndA2 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 sndA2 A3 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a31oi_4 A1 A2 A3 B1 VGND VNB VPB VPWR Y
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 pndA A3 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 Y B1 pndA VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 sndA2 VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 sndA2 A3 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a32o_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 pndA A3 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 y B1 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 y B2 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 y A1 sndA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 sndA2 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 sndA2 A3 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 sndB1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 sndB1 B2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a32o_2 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 pndA A3 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 y B1 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 y B2 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 y A1 sndA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 sndA2 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 sndA2 A3 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 sndB1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 sndB1 B2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a32o_4 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 pndA A3 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 y B1 pndA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 y B2 pndA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 y A1 sndA1 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 sndA2 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 sndA2 A3 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 sndB1 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 sndB1 B2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a32oi_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR Y
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 pndA A3 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 Y B1 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 Y B2 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 sndA2 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 sndA2 A3 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 sndB1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 sndB1 B2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a32oi_2 A1 A2 A3 B1 B2 VGND VNB VPB VPWR Y
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 pndA A3 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 Y B1 pndA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 Y B2 pndA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 sndA2 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 sndA2 A3 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 sndB1 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 sndB1 B2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a32oi_4 A1 A2 A3 B1 B2 VGND VNB VPB VPWR Y
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 pndA A3 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 Y B1 pndA VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 Y B2 pndA VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 sndA2 VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 sndA2 A3 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 sndB1 VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 sndB1 B2 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a41o_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 pndA A3 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA3 pndA A4 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 y B1 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 y A1 sndA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 sndA2 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 sndA2 A3 sndA3 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA3 sndA3 A4 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a41o_2 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 pndA A3 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA3 pndA A4 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 y B1 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 y A1 sndA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 sndA2 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 sndA2 A3 sndA3 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA3 sndA3 A4 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a41o_4 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 pndA A3 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA3 pndA A4 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 y B1 pndA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 y A1 sndA1 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 sndA2 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 sndA2 A3 sndA3 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA3 sndA3 A4 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a41oi_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR Y
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 pndA A3 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA3 pndA A4 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 Y B1 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 sndA2 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 sndA2 A3 sndA3 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA3 sndA3 A4 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a41oi_2 A1 A2 A3 A4 B1 VGND VNB VPB VPWR Y
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 pndA A3 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA3 pndA A4 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 Y B1 pndA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 sndA2 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 sndA2 A3 sndA3 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA3 sndA3 A4 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a41oi_4 A1 A2 A3 A4 B1 VGND VNB VPB VPWR Y
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 pndA A3 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA3 pndA A4 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 Y B1 pndA VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 sndA2 VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 sndA2 A3 sndA3 VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA3 sndA3 A4 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a211o_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 pndB B1 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 y C1 pndB VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 y A1 sndA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 y C1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a211o_2 A1 A2 B1 C1 VGND VNB VPB VPWR X
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 pndB B1 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 y C1 pndB VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 y A1 sndA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 y C1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a211o_4 A1 A2 B1 C1 VGND VNB VPB VPWR X
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 pndB B1 pndA VPB pfet_01v8_hvt w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB20 pnd2B B1 pndA VPB pfet_01v8_hvt w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 y C1 pndB VPB pfet_01v8_hvt w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC20 y C1 pnd2B VPB pfet_01v8_hvt w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 y A1 sndA1 VNB nfet_01v8 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA20 y A1 snd2A1 VNB nfet_01v8 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA21 snd2A1 A2 VGND VNB nfet_01v8 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 y C1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a211oi_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 pndB B1 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 Y C1 pndB VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 Y C1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a211oi_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 pndB B1 pndA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 Y C1 pndB VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 Y C1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a211oi_4 A1 A2 B1 C1 VGND VNB VPB VPWR Y
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 pndB B1 pndA VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 Y C1 pndB VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 Y C1 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a221o_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 pndB B1 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 pndB B2 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 y C1 pndB VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 y A1 sndA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 sndB1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 sndB1 B2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 y C1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a221o_2 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 pndB B1 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 pndB B2 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 y C1 pndB VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 y A1 sndA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 sndB1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 sndB1 B2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 y C1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a221o_4 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 pndB B1 pndA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 pndB B2 pndA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 y C1 pndB VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 y A1 sndA1 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 sndB1 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 sndB1 B2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 y C1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a221oi_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 pndB B1 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 pndB B2 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 Y C1 pndB VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 sndB1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 sndB1 B2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 Y C1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a221oi_2 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 pndB B1 pndA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 pndB B2 pndA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 Y C1 pndB VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 sndB1 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 sndB1 B2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 Y C1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a221oi_4 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 pndB B1 pndA VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 pndB B2 pndA VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 Y C1 pndB VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 sndB1 VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 sndB1 B2 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 Y C1 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a222oi_1 A1 A2 B1 B2 C1 C2 VGND VNB VPB VPWR Y
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 pndB B1 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 pndB B2 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 Y C1 pndB VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI8 Y C2 pndB VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 sndB1 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 sndB1 B2 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 Y C1 net62 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI10 net62 C2 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a311o_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 pndA A3 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 pndB B1 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 y C1 pndB VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 y A1 sndA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 sndA2 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 sndA2 A3 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 y C1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a311o_2 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 pndA A3 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 pndB B1 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 y C1 pndB VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 y A1 sndA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 sndA2 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 sndA2 A3 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 y C1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a311o_4 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 pndA A3 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 pndB B1 pndA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 y C1 pndB VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 y A1 sndA1 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 sndA2 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 sndA2 A3 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 y C1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a311oi_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR Y
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 pndA A3 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 pndB B1 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 Y C1 pndB VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 sndA2 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 sndA2 A3 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 Y C1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a311oi_2 A1 A2 A3 B1 C1 VGND VNB VPB VPWR Y
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 pndA A3 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 pndB B1 pndA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 Y C1 pndB VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 sndA2 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 sndA2 A3 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 Y C1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a311oi_4 A1 A2 A3 B1 C1 VGND VNB VPB VPWR Y
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 pndA A3 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 pndB B1 pndA VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 Y C1 pndB VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 sndA2 VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 sndA2 A3 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 Y C1 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a2111o_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 pndB B1 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 pndC C1 pndB VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPD0 y D1 pndC VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 y A1 sndA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 y C1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMND0 y D1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a2111o_2 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 pndB B1 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 pndC C1 pndB VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPD0 y D1 pndC VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 y A1 sndA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 y C1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMND0 y D1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a2111o_4 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 pndB B1 pndA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 pndC C1 pndB VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPD0 y D1 pndC VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 y A1 sndA1 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 y C1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMND0 y D1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a2111oi_0 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 pndB B1 pndA VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 pndC C1 pndB VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPD0 Y D1 pndC VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 Y C1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMND0 Y D1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a2111oi_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 pndB B1 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 pndC C1 pndB VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPD0 Y D1 pndC VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 Y C1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMND0 Y D1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a2111oi_2 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 pndB B1 pndA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 pndC C1 pndB VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPD0 Y D1 pndC VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 Y C1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMND0 Y D1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a2111oi_4 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 pndB B1 pndA VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 pndC C1 pndB VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPD0 Y D1 pndC VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 Y C1 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMND0 Y D1 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__and2_0 A B VGND VNB VPB VPWR X
MMP0 y A VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 y B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 X y VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A sndA VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 X y VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
MMP0 y A VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 y B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A sndA VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__and2_2 A B VGND VNB VPB VPWR X
MMP0 y A VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 y B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A sndA VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__and2_4 A B VGND VNB VPB VPWR X
MMP0 y A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 y B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A sndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
MMP0 y A VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 y B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 A A_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A sndA VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 A A_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__and2b_2 A_N B VGND VNB VPB VPWR X
MMP0 y A VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 y B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 A A_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A sndA VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 A A_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__and2b_4 A_N B VGND VNB VPB VPWR X
MMP0 y A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 y B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 A A_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A sndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 A A_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
MMP0 y A VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 y B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 y C VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A sndA VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B sndB VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 sndB C VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__and3_2 A B C VGND VNB VPB VPWR X
MMP0 y A VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 y B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 y C VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A sndA VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B sndB VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 sndB C VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__and3_4 A B C VGND VNB VPB VPWR X
MMP0 y A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 y B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 y C VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A sndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B sndB VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 sndB C VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
MMP0 y A VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 y B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 y C VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 A A_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A sndA VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B sndB VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 sndB C VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 A A_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__and3b_2 A_N B C VGND VNB VPB VPWR X
MMP0 y A VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 y B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 y C VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 A A_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A sndA VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B sndB VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 sndB C VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 A A_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__and3b_4 A_N B C VGND VNB VPB VPWR X
MMP0 y A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 y B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 y C VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 A A_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A sndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B sndB VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 sndB C VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 A A_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__and4_1 A B C D VGND VNB VPB VPWR X
MMP0 y A VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 y B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 y C VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 y D VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A sndA VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B sndB VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 sndB C sndC VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 sndC D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__and4_2 A B C D VGND VNB VPB VPWR X
MMP0 y A VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 y B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 y C VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 y D VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A sndA VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B sndB VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 sndB C sndC VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 sndC D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__and4_4 A B C D VGND VNB VPB VPWR X
MMP0 y A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 y B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 y C VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 y D VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A sndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B sndB VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 sndB C sndC VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 sndC D VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__and4b_1 A_N B C D VGND VNB VPB VPWR X
MMP0 y A VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 y B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 y C VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 y D VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 A A_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A sndA VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B sndB VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 sndB C sndC VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 sndC D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 A A_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__and4b_2 A_N B C D VGND VNB VPB VPWR X
MMP0 y A VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 y B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 y C VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 y D VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 A A_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A sndA VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B sndB VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 sndB C sndC VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 sndC D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 A A_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__and4b_4 A_N B C D VGND VNB VPB VPWR X
MMP0 y A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 y B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 y C VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 y D VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 A A_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A sndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B sndB VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 sndB C sndC VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 sndC D VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 A A_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__and4bb_1 A_N B_N C D VGND VNB VPB VPWR X
MMP0 y A VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 y B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 y C VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 y D VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 A A_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 B B_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A sndA VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B sndB VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 sndB C sndC VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 sndC D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 A A_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 B B_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__and4bb_2 A_N B_N C D VGND VNB VPB VPWR X
MMP0 y A VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 y B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 y C VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 y D VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 A A_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 B B_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A sndA VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B sndB VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 sndB C sndC VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 sndC D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 A A_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 B B_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__and4bb_4 A_N B_N C D VGND VNB VPB VPWR X
MMP0 y A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 y B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 y C VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 y D VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 A A_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 B B_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A sndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B sndB VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 sndB C sndC VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 sndC D VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 A A_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 B B_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
MMIN1 Ab A VGND VNB nfet_01v8 m=1 w=0.52 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 X Ab VGND VNB nfet_01v8 m=1 w=0.52 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Ab A VPWR VPB pfet_01v8_hvt m=1 w=0.79 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X Ab VPWR VPB pfet_01v8_hvt m=1 w=0.79 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
MMIN1 Ab A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 X Ab VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Ab A VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X Ab VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
MMIN1 Ab A VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 X Ab VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Ab A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X Ab VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__buf_6 A VGND VNB VPB VPWR X
MMIN1 Ab A VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 X Ab VGND VNB nfet_01v8 m=6 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Ab A VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X Ab VPWR VPB pfet_01v8_hvt m=6 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__buf_8 A VGND VNB VPB VPWR X
MMIN1 Ab A VGND VNB nfet_01v8 m=3 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 X Ab VGND VNB nfet_01v8 m=8 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Ab A VPWR VPB pfet_01v8_hvt m=3 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X Ab VPWR VPB pfet_01v8_hvt m=8 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__buf_12 A VGND VNB VPB VPWR X
MMIN1 Ab A VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 X Ab VGND VNB nfet_01v8 m=12 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Ab A VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X Ab VPWR VPB pfet_01v8_hvt m=12 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__buf_16 A VGND VNB VPB VPWR X
MMIN1 Ab A VGND VNB nfet_01v8 m=6 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 X Ab VGND VNB nfet_01v8 m=16 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Ab A VPWR VPB pfet_01v8_hvt m=6 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X Ab VPWR VPB pfet_01v8_hvt m=16 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__bufbuf_8 A VGND VNB VPB VPWR X
MMIN1 Ab A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 Abb Ab VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 Abbb Abb VGND VNB nfet_01v8 m=3 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN4 X Abbb VGND VNB nfet_01v8 m=8 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP4 X Abbb VPWR VPB pfet_01v8_hvt m=8 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Ab A VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 Abb Ab VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI5 Abbb Abb VPWR VPB pfet_01v8_hvt m=3 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__bufbuf_16 A VGND VNB VPB VPWR X
MMIN1 Ab A VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 Abb Ab VGND VNB nfet_01v8 m=3 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 Abbb Abb VGND VNB nfet_01v8 m=6 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN4 X Abbb VGND VNB nfet_01v8 m=16 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP4 X Abbb VPWR VPB pfet_01v8_hvt m=16 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Ab A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 Abb Ab VPWR VPB pfet_01v8_hvt m=3 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI5 Abbb Abb VPWR VPB pfet_01v8_hvt m=6 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__bufinv_8 A VGND VNB VPB VPWR Y
MMIN1 Ab A VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 Abb Ab VGND VNB nfet_01v8 m=3 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 Y Abb VGND VNB nfet_01v8 m=8 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Ab A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 Abb Ab VPWR VPB pfet_01v8_hvt m=3 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP3 Y Abb VPWR VPB pfet_01v8_hvt m=8 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__bufinv_16 A VGND VNB VPB VPWR Y
MMIN1 Ab A VGND VNB nfet_01v8 m=3 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 Abb Ab VGND VNB nfet_01v8 m=6 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 Y Abb VGND VNB nfet_01v8 m=16 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Ab A VPWR VPB pfet_01v8_hvt m=3 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 Abb Ab VPWR VPB pfet_01v8_hvt m=6 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP3 Y Abb VPWR VPB pfet_01v8_hvt m=16 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
MMIN0 Ab A VGND VNB nfet_01v8 m=1 w=0.52 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 X Ab VGND VNB nfet_01v8 m=1 w=0.52 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 Ab A VPWR VPB pfet_01v8_hvt m=1 w=0.79 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 X Ab VPWR VPB pfet_01v8_hvt m=1 w=0.79 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
MMIN0 Ab A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 X Ab VGND VNB nfet_01v8 m=2 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 Ab A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 X Ab VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
MMIN0 Ab A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 X Ab VGND VNB nfet_01v8 m=4 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 Ab A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 X Ab VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__clkbuf_8 A VGND VNB VPB VPWR X
MMIN0 Ab A VGND VNB nfet_01v8 m=2 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 X Ab VGND VNB nfet_01v8 m=8 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 Ab A VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 X Ab VPWR VPB pfet_01v8_hvt m=8 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
MMIN0 Ab A VGND VNB nfet_01v8 m=4 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 X Ab VGND VNB nfet_01v8 m=16 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 Ab A VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 X Ab VPWR VPB pfet_01v8_hvt m=16 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__clkdlybuf4s15_1 A VGND VNB VPB VPWR X
MMIN1 Ab A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 A2 Ab VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI5 Ab2 A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI4 X Ab2 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Ab A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 A2 Ab VPWR VPB pfet_01v8_hvt m=1 w=0.82 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI7 Ab2 A2 VPWR VPB pfet_01v8_hvt m=1 w=0.82 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 X Ab2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__clkdlybuf4s15_2 A VGND VNB VPB VPWR X
MMIN1 Ab A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 A2 Ab VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI5 Ab2 A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI4 X Ab2 VGND VNB nfet_01v8 m=2 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Ab A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 A2 Ab VPWR VPB pfet_01v8_hvt m=1 w=0.82 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI7 Ab2 A2 VPWR VPB pfet_01v8_hvt m=1 w=0.82 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 X Ab2 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__clkdlybuf4s18_1 A VGND VNB VPB VPWR X
MMIN1 Ab A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 A2 Ab VGND VNB nfet_01v8 m=1 w=0.65 l=0.18 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI5 Ab2 A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.18 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI4 X Ab2 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Ab A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 A2 Ab VPWR VPB pfet_01v8_hvt m=1 w=0.82 l=0.18 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI7 Ab2 A2 VPWR VPB pfet_01v8_hvt m=1 w=0.82 l=0.18 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 X Ab2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__clkdlybuf4s18_2 A VGND VNB VPB VPWR X
MMIN1 Ab A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 A2 Ab VGND VNB nfet_01v8 m=1 w=0.65 l=0.18 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI5 Ab2 A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.18 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI4 X Ab2 VGND VNB nfet_01v8 m=2 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Ab A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 A2 Ab VPWR VPB pfet_01v8_hvt m=1 w=0.82 l=0.18 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI7 Ab2 A2 VPWR VPB pfet_01v8_hvt m=1 w=0.82 l=0.18 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 X Ab2 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__clkdlybuf4s25_1 A VGND VNB VPB VPWR X
MMIN1 Ab A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 A2 Ab VGND VNB nfet_01v8 m=1 w=0.65 l=0.25 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI5 Ab2 A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.25 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI4 X Ab2 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Ab A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 A2 Ab VPWR VPB pfet_01v8_hvt m=1 w=0.82 l=0.25 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI7 Ab2 A2 VPWR VPB pfet_01v8_hvt m=1 w=0.82 l=0.25 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 X Ab2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__clkdlybuf4s25_2 A VGND VNB VPB VPWR X
MMIN1 Ab A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 A2 Ab VGND VNB nfet_01v8 m=1 w=0.65 l=0.25 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI5 Ab2 A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.25 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI4 X Ab2 VGND VNB nfet_01v8 m=2 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Ab A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 A2 Ab VPWR VPB pfet_01v8_hvt m=1 w=0.82 l=0.25 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI7 Ab2 A2 VPWR VPB pfet_01v8_hvt m=1 w=0.82 l=0.25 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 X Ab2 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__clkdlybuf4s50_1 A VGND VNB VPB VPWR X
MMIN1 Ab A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 A2 Ab VGND VNB nfet_01v8 m=1 w=0.65 l=0.5 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI5 Ab2 A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.5 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI4 X Ab2 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Ab A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 A2 Ab VPWR VPB pfet_01v8_hvt m=1 w=0.82 l=0.5 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI7 Ab2 A2 VPWR VPB pfet_01v8_hvt m=1 w=0.82 l=0.5 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 X Ab2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__clkdlybuf4s50_2 A VGND VNB VPB VPWR X
MMIN1 Ab A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 A2 Ab VGND VNB nfet_01v8 m=1 w=0.65 l=0.5 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI5 Ab2 A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.5 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI4 X Ab2 VGND VNB nfet_01v8 m=2 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Ab A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 A2 Ab VPWR VPB pfet_01v8_hvt m=1 w=0.82 l=0.5 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI7 Ab2 A2 VPWR VPB pfet_01v8_hvt m=1 w=0.82 l=0.5 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 X Ab2 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__clkinv_1 A VGND VNB VPB VPWR Y
MMIN0 Y A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 Y A VPWR VPB pfet_01v8_hvt m=2 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__clkinv_2 A VGND VNB VPB VPWR Y
MMIN0 Y A VGND VNB nfet_01v8 m=2 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 Y A VPWR VPB pfet_01v8_hvt m=3 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__clkinv_4 A VGND VNB VPB VPWR Y
MMIN0 Y A VGND VNB nfet_01v8 m=4 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 Y A VPWR VPB pfet_01v8_hvt m=6 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__clkinv_8 A VGND VNB VPB VPWR Y
MMIN0 Y A VGND VNB nfet_01v8 m=8 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 Y A VPWR VPB pfet_01v8_hvt m=12 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__clkinv_16 A VGND VNB VPB VPWR Y
MMIN0 Y A VGND VNB nfet_01v8 m=16 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 Y A VPWR VPB pfet_01v8_hvt m=24 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__clkinvlp_2 A VGND VNB VPB VPWR Y
MMIP0 Y A VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.25 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI5 net36 A VGND VNB nfet_01v8 m=1 w=0.55 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 Y A net36 VNB nfet_01v8 m=1 w=0.55 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__clkinvlp_4 A VGND VNB VPB VPWR Y
MMIP0 Y A VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.25 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 Y A net31 VNB nfet_01v8 m=1 w=0.55 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI7 net35 A VGND VNB nfet_01v8 m=1 w=0.55 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 net31 A VGND VNB nfet_01v8 m=1 w=0.55 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI5 Y A net35 VNB nfet_01v8 m=1 w=0.55 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__conb_1 VGND VNB VPB VPWR HI LO
rI12 VGND LO short
rI11 HI VPWR short
.ENDS

.SUBCKT sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
MI1 VGND VPWR VGND VNB nfet_01v8 m=1 w=0.55 l=0.59 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI2 VPWR VGND VPWR VPB pfet_01v8_hvt m=1 w=0.87 l=0.59 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
MI2 VPWR VGND VPWR VPB pfet_01v8_hvt m=1 w=0.87 l=1.05 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI1 VGND VPWR VGND VNB nfet_01v8 m=1 w=0.55 l=1.05 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
MI1 VGND VPWR VGND VNB nfet_01v8 m=1 w=0.55 l=1.97 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI2 VPWR VGND VPWR VPB pfet_01v8_hvt m=1 w=0.87 l=1.97 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
MI1 VGND VPWR VGND VNB nfet_01v8 m=1 w=0.55 l=2.89 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI2 VPWR VGND VPWR VPB pfet_01v8_hvt m=1 w=0.87 l=2.89 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__decap_12 VGND VNB VPB VPWR
MI1 VGND VPWR VGND VNB nfet_01v8 m=1 w=0.55 l=4.73 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI2 VPWR VGND VPWR VPB pfet_01v8_hvt m=1 w=0.87 l=4.73 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dfbbn_1 CLK_N D RESET_B SET_B VGND VNB VPB VPWR Q Q_N
MI46 clkneg clkpos VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 db D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI642 RESET RESET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI676 M1 M0 net141 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI675 net141 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 Q net162 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI677 M1 RESET net141 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 M0 clkpos net125 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 clkpos CLK_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 net125 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 S0 clkneg net110 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net110 net82 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 Q_N net82 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 net162 net82 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI668 S0 clkpos net93 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI667 net93 M1 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI630 net82 RESET net81 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI3 net82 S0 net81 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI7 net81 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI679 M1 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI669 S0 clkneg net218 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI660 Q net162 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI9 net82 S0 net221 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI670 net218 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI678 net165 RESET VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI662 net210 net82 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 S0 clkpos net210 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI10 net82 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI11 net221 RESET VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 net194 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI665 db D VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 M0 clkneg net194 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI643 RESET RESET_B VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 clkneg clkpos VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 clkpos CLK_N VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI680 M1 M0 net165 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI663 net162 net82 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI661 Q_N net82 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dfbbn_2 CLK_N D RESET_B SET_B VGND VNB VPB VPWR Q Q_N
MI46 clkneg clkpos VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 db D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI642 RESET RESET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI676 M1 M0 net141 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI675 net141 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 Q net162 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI677 M1 RESET net141 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 M0 clkpos net125 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 clkpos CLK_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 net125 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 S0 clkneg net110 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net110 net82 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 Q_N net82 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 net162 net82 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI668 S0 clkpos net93 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI667 net93 M1 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI630 net82 RESET net81 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI3 net82 S0 net81 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI7 net81 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI679 M1 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI669 S0 clkneg net218 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI660 Q net162 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI9 net82 S0 net221 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI670 net218 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI678 net165 RESET VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI662 net210 net82 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 S0 clkpos net210 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI10 net82 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI11 net221 RESET VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 net194 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI665 db D VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 M0 clkneg net194 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI643 RESET RESET_B VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 clkneg clkpos VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 clkpos CLK_N VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI680 M1 M0 net165 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI663 net162 net82 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI661 Q_N net82 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dfbbp_1 CLK D RESET_B SET_B VGND VNB VPB VPWR Q Q_N
MI46 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 db D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI642 RESET RESET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI676 M1 M0 net141 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI675 net141 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 Q net162 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI677 M1 RESET net141 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 M0 clkpos net118 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 net118 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 S0 clkneg net110 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net110 net82 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 Q_N net82 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 net162 net82 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI668 S0 clkpos net93 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI667 net93 M1 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI630 net82 RESET net81 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI3 net82 S0 net81 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI7 net81 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI679 M1 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI669 S0 clkneg net218 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI660 Q net162 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI9 net82 S0 net221 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI670 net218 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI678 net165 RESET VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI662 net210 net82 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 S0 clkpos net210 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI10 net82 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI11 net221 RESET VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 net194 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI665 db D VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 M0 clkneg net194 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI643 RESET RESET_B VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI680 M1 M0 net165 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI663 net162 net82 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI661 Q_N net82 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dfrbp_1 CLK D RESET_B VGND VNB VPB VPWR Q Q_N
MI46 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net99 s0 net125 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net125 RESET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI33 net118 RESET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI4 M0 clkpos net110 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 net110 M1 net118 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 s0 clkneg net98 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 Q net99 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net98 net99 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI647 M1 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI39 db D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 M1 clkpos s0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI53 net142 net99 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI50 Q_N net142 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI662 net190 net99 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 net99 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 s0 clkpos net190 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net99 s0 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI30 net169 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI31 M0 clkneg net169 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI32 net169 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI660 Q net99 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI40 db D VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 M1 clkneg s0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI52 net142 net99 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI51 Q_N net142 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dfrbp_2 CLK D RESET_B VGND VNB VPB VPWR Q Q_N
MI46 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net99 s0 net125 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net125 RESET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI33 net118 RESET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI4 M0 clkpos net110 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 net110 M1 net118 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 s0 clkneg net98 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 Q net99 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net98 net99 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI647 M1 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI39 db D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 M1 clkpos s0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI53 net142 net99 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI50 Q_N net142 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI662 net181 net99 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 net99 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 s0 clkpos net181 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net99 s0 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI30 net169 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI31 M0 clkneg net169 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI32 net169 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI660 Q net99 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI40 db D VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 M1 clkneg s0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI52 net142 net99 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI51 Q_N net142 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dfrtn_1 CLK_N D RESET_B VGND VNB VPB VPWR Q
MI46 clkneg clkpos VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net83 net121 net109 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net109 RESET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI33 net102 RESET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI4 M0 clkpos net94 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 net94 M1 net102 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 net121 clkneg net82 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 Q net83 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net82 net83 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 clkpos CLK_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI647 M1 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI39 db D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 M1 clkpos net121 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 clkneg clkpos VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI662 net166 net83 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 net83 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 net121 clkpos net166 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net83 net121 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI30 net145 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI31 M0 clkneg net145 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI32 net145 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI660 Q net83 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 clkpos CLK_N VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI40 db D VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 M1 clkneg net121 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dfrtp_1 CLK D RESET_B VGND VNB VPB VPWR Q
MI46 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net82 s0 net108 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net108 RESET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI33 net101 RESET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI4 M0 clkpos net93 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 net93 M1 net101 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 s0 clkneg net81 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 Q net82 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net81 net82 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI647 M1 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI39 db D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 M1 clkpos s0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI662 net165 net82 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 net82 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 s0 clkpos net165 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net82 s0 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI30 net144 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI31 M0 clkneg net144 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI32 net144 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI660 Q net82 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI40 db D VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 M1 clkneg s0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dfrtp_2 CLK D RESET_B VGND VNB VPB VPWR Q
MI46 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net82 s0 net108 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net108 RESET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI33 net101 RESET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI4 M0 clkpos net93 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 net93 M1 net101 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 s0 clkneg net81 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 Q net82 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net81 net82 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI647 M1 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI39 db D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 M1 clkpos s0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI662 net156 net82 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 net82 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 s0 clkpos net156 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net82 s0 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI30 net144 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI31 M0 clkneg net144 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI32 net144 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI660 Q net82 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI40 db D VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 M1 clkneg s0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dfrtp_4 CLK D RESET_B VGND VNB VPB VPWR Q
MI46 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net82 s0 net108 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net108 RESET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI33 net101 RESET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI4 M0 clkpos net93 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 net93 M1 net101 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 s0 clkneg net81 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 Q net82 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net81 net82 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI647 M1 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI39 db D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 M1 clkpos s0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI662 net165 net82 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 net82 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 s0 clkpos net165 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net82 s0 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI30 net144 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI31 M0 clkneg net144 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI32 net144 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI660 Q net82 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI40 db D VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 M1 clkneg s0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dfsbp_1 CLK D SET_B VGND VNB VPB VPWR Q Q_N
MI36 net129 M0 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI39 db D VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 M1 M0 net112 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net80 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 S0 clkpos net129 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI46 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI25 net97 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI26 S0 clkneg net89 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI27 net89 S1 net97 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI647 S1 S0 VGND VNB nfet_01v8 m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 M0 clkpos net80 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net112 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 net141 S0 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 Q net141 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI49 Q_N S0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI40 db D VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI38 S0 clkneg net192 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI37 net192 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 M1 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI662 net169 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 M0 clkneg net169 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 net156 S1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI5 S0 clkpos net156 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI24 S0 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 S1 S0 VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI663 net141 S0 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI660 Q net141 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI50 Q_N S0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dfsbp_2 CLK D SET_B VGND VNB VPB VPWR Q Q_N
MI36 net128 M0 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI39 db D VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 M1 M0 net111 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net79 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 S0 clkpos net128 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI46 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI25 net96 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI26 S0 clkneg net88 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI27 net88 S1 net96 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI647 S1 S0 VGND VNB nfet_01v8 m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 M0 clkpos net79 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net111 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 net140 S0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 Q net140 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI49 Q_N S0 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI40 db D VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI38 S0 clkneg net191 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI37 net191 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 M1 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI662 net168 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 M0 clkneg net168 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 net155 S1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI5 S0 clkpos net155 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI24 S0 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 S1 S0 VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI663 net140 S0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI660 Q net140 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI50 Q_N S0 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dfstp_1 CLK D SET_B VGND VNB VPB VPWR Q
MI36 net120 M0 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI39 db D VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 M1 M0 net103 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net71 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 S0 clkpos net120 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI46 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI25 net88 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI26 S0 clkneg net80 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI27 net80 S1 net88 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI647 S1 S0 VGND VNB nfet_01v8 m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 M0 clkpos net71 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net103 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 net128 S0 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 Q net128 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI40 db D VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI38 S0 clkneg net179 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI37 net179 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 M1 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI662 net156 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 M0 clkneg net156 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 net143 S1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI5 S0 clkpos net143 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI24 S0 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 S1 S0 VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI663 net128 S0 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI660 Q net128 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dfstp_2 CLK D SET_B VGND VNB VPB VPWR Q
MI36 net120 M0 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI39 db D VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 M1 M0 net103 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net71 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 S0 clkpos net120 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI46 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI25 net88 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI26 S0 clkneg net80 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI27 net80 S1 net88 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI647 S1 S0 VGND VNB nfet_01v8 m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 M0 clkpos net71 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net103 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 net128 S0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 Q net128 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI40 db D VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI38 S0 clkneg net179 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI37 net179 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 M1 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI662 net156 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 M0 clkneg net156 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 net143 S1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI5 S0 clkpos net143 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI24 S0 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 S1 S0 VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI663 net128 S0 VPWR VPB pfet_01v8_hvt m=1 w=1 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI660 Q net128 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dfstp_4 CLK D SET_B VGND VNB VPB VPWR Q
MI36 net120 M0 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI39 db D VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 M1 M0 net103 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net71 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 S0 clkpos net120 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI46 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI25 net88 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI26 S0 clkneg net80 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI27 net80 S1 net88 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI647 S1 S0 VGND VNB nfet_01v8 m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 M0 clkpos net71 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net103 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 net128 S0 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 Q net128 VGND VNB nfet_01v8 m=5 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI40 db D VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI38 S0 clkneg net179 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI37 net179 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 M1 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI662 net156 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 M0 clkneg net156 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 net143 S1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI5 S0 clkpos net143 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI24 S0 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 S1 S0 VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI663 net128 S0 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI660 Q net128 VPWR VPB pfet_01v8_hvt m=5 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dfxbp_1 CLK D VGND VNB VPB VPWR Q Q_N
MI657 M0 clkpos net96 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net96 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI646 Q S1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI669 net88 S1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 db D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI642 S0 clkneg net72 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI641 net72 S1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 M1 clkpos S0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 S1 S0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI635 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 M1 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI665 Q_N net88 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 M0 clkneg net128 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 S1 S0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI644 S0 clkpos net147 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI639 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.75 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI670 net88 S1 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI643 net147 S1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net128 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI645 Q S1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 db D VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 M1 clkneg S0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI666 Q_N net88 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dfxbp_2 CLK D VGND VNB VPB VPWR Q Q_N
MI657 M0 clkpos net96 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net96 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI646 Q S1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI669 net88 S1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 db D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI642 S0 clkneg net72 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI641 net72 S1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 M1 clkpos S0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 S1 S0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI635 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 M1 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI665 Q_N net88 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 M0 clkneg net128 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 S1 S0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI644 S0 clkpos net147 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI639 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.75 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI670 net88 S1 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI643 net147 S1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net128 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI645 Q S1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 db D VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 M1 clkneg S0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI666 Q_N net88 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dfxtp_1 CLK D VGND VNB VPB VPWR Q
MI657 M0 clkpos net79 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net79 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI646 Q S1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 db D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI642 S0 clkneg net59 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI641 net59 S1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 M1 clkpos S0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 S1 S0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI635 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 M1 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 M0 clkneg net107 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 S1 S0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI644 S0 clkpos net122 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI639 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.75 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI643 net122 S1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net107 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI645 Q S1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 db D VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 M1 clkneg S0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dfxtp_2 CLK D VGND VNB VPB VPWR Q
MI657 M0 clkpos net79 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net79 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI646 Q S1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 db D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI642 S0 clkneg net59 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI641 net59 S1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 M1 clkpos S0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 S1 S0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI635 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 M1 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 M0 clkneg net107 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 S1 S0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI644 S0 clkpos net122 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI639 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.75 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI643 net122 S1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net107 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI645 Q S1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 db D VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 M1 clkneg S0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dfxtp_4 CLK D VGND VNB VPB VPWR Q
MI657 M0 clkpos net79 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net79 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI646 Q S1 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 db D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI642 S0 clkneg net59 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI641 net59 S1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 M1 clkpos S0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 S1 S0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI635 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 M1 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 M0 clkneg net107 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 S1 S0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI644 S0 clkpos net122 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI639 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.75 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI643 net122 S1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net107 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI645 Q S1 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 db D VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 M1 clkneg S0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__diode_2 DIODE VGND VNB VPB VPWR
.ENDS

.SUBCKT sky130_fd_sc_hd__dlclkp_1 CLK GATE VGND VNB VPB VPWR GCLK
MI662 net75 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 M0 clkpos net75 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 net63 CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net63 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 m1 M0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI38 M0 clkneg net54 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI37 net54 GATE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 clkneg clkpos VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 clkpos CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI660 GCLK net63 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI20 m1 M0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 M0 clkneg net110 VNB nfet_01v8 m=1 w=0.39 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net110 m1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 M0 clkpos net91 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net99 CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net63 m1 net99 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI36 net91 GATE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI46 clkneg clkpos VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 clkpos CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 GCLK net63 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dlclkp_2 CLK GATE VGND VNB VPB VPWR GCLK
MI662 net75 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 M0 clkpos net75 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 net63 CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net63 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 m1 M0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI38 M0 clkneg net54 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI37 net54 GATE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 clkneg clkpos VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 clkpos CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI660 GCLK net63 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI20 m1 M0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 M0 clkneg net110 VNB nfet_01v8 m=1 w=0.39 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net110 m1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 M0 clkpos net91 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net99 CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net63 m1 net99 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI36 net91 GATE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI46 clkneg clkpos VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 clkpos CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 GCLK net63 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dlclkp_4 CLK GATE VGND VNB VPB VPWR GCLK
MI662 net75 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 M0 clkpos net75 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 net63 CLK VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net63 m1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 m1 M0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI38 M0 clkneg net54 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI37 net54 GATE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 clkneg clkpos VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 clkpos CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI660 GCLK net63 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI20 m1 M0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 M0 clkneg net110 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net110 m1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 M0 clkpos net91 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net99 CLK VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net63 m1 net99 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI36 net91 GATE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI46 clkneg clkpos VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 clkpos CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 GCLK net63 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dlrbn_1 D GATE_N RESET_B VGND VNB VPB VPWR Q Q_N
MI635 clkneg clkpos VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 Q_N net125 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 M0 clkneg net61 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI646 net125 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 Q m1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI633 clkpos GATE_N VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 m1 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI18 net61 db VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 net57 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 M0 clkpos net57 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 m1 M0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 db D VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 clkpos GATE_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI647 Q_N net125 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 Q m1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI645 net125 m1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net108 RESET_B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 M0 clkneg net116 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net116 m1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 m1 M0 net108 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkneg clkpos VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 db D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 M0 clkpos net96 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI20 net96 db VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dlrbn_2 D GATE_N RESET_B VGND VNB VPB VPWR Q Q_N
MI635 clkneg clkpos VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 Q_N net125 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 M0 clkneg net61 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI646 net125 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 Q m1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI633 clkpos GATE_N VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 m1 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI18 net61 db VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 net57 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 M0 clkpos net57 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 m1 M0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 db D VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 clkpos GATE_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI647 Q_N net125 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 Q m1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI645 net125 m1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net108 RESET_B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 M0 clkneg net116 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net116 m1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 m1 M0 net108 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkneg clkpos VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 db D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 M0 clkpos net96 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI20 net96 db VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dlrbp_1 D GATE RESET_B VGND VNB VPB VPWR Q Q_N
MI635 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 Q_N net125 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 M0 clkneg net61 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI646 net125 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 Q m1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI633 clkneg GATE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 m1 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI18 net61 db VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 net57 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 M0 clkpos net57 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 m1 M0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 db D VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 clkneg GATE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI647 Q_N net125 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 Q m1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI645 net125 m1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net121 RESET_B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 M0 clkneg net116 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net116 m1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 m1 M0 net121 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 db D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 M0 clkpos net96 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI20 net96 db VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dlrbp_2 D GATE RESET_B VGND VNB VPB VPWR Q Q_N
MI635 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 Q_N net125 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 M0 clkneg net61 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI646 net125 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 Q m1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI633 clkneg GATE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 m1 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI18 net61 db VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 net57 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 M0 clkpos net57 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 m1 M0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 db D VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 clkneg GATE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI647 Q_N net125 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 Q m1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI645 net125 m1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net108 RESET_B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 M0 clkneg net116 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net116 m1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 m1 M0 net108 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 db D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 M0 clkpos net96 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI20 net96 db VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dlrtn_1 D GATE_N RESET_B VGND VNB VPB VPWR Q
MI635 clkneg clkpos VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 M0 clkneg net54 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 Q m1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI633 clkpos GATE_N VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 m1 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI18 net54 db VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 net50 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 M0 clkpos net50 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 m1 M0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 db D VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 clkpos GATE_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 Q m1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net93 RESET_B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 M0 clkneg net101 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net101 m1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 m1 M0 net93 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkneg clkpos VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 db D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 M0 clkpos net81 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI20 net81 db VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dlrtn_2 D GATE_N RESET_B VGND VNB VPB VPWR Q
MI635 clkneg clkpos VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 M0 clkneg net54 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 Q m1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI633 clkpos GATE_N VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 m1 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI18 net54 db VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 net50 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 M0 clkpos net50 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 m1 M0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 db D VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 clkpos GATE_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 Q m1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net93 RESET_B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 M0 clkneg net101 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net101 m1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 m1 M0 net93 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkneg clkpos VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 db D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 M0 clkpos net81 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI20 net81 db VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dlrtn_4 D GATE_N RESET_B VGND VNB VPB VPWR Q
MI635 clkneg clkpos VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 M0 clkneg net55 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 Q m1 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI633 clkpos GATE_N VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 m1 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI18 net55 db VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 net51 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 M0 clkpos net51 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 m1 M0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 db D VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 clkpos GATE_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 Q m1 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net94 RESET_B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 M0 clkneg net102 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net102 m1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 m1 M0 net94 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkneg clkpos VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 db D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 M0 clkpos net82 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI20 net82 db VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dlrtp_1 D GATE RESET_B VGND VNB VPB VPWR Q
MI635 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 M0 clkneg net54 VPB pfet_01v8_hvt m=1 w=0.36 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 Q m1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI633 clkneg GATE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 m1 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI18 net54 db VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 net50 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 M0 clkpos net50 VPB pfet_01v8_hvt m=1 w=0.36 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 m1 M0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 db D VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 clkneg GATE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 Q m1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net93 RESET_B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 M0 clkneg net101 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net101 m1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 m1 M0 net93 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 db D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 M0 clkpos net81 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI20 net81 db VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dlrtp_2 D GATE RESET_B VGND VNB VPB VPWR Q
MI635 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 M0 clkneg net54 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 Q m1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI633 clkneg GATE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 m1 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI18 net54 db VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 net50 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 M0 clkpos net50 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 m1 M0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 db D VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 clkneg GATE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 Q m1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net93 RESET_B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 M0 clkneg net101 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net101 m1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 m1 M0 net93 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 db D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 M0 clkpos net81 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI20 net81 db VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dlrtp_4 D GATE RESET_B VGND VNB VPB VPWR Q
MI635 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 M0 clkneg net55 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 Q m1 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI633 clkneg GATE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 m1 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI18 net55 db VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 net51 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 M0 clkpos net51 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 m1 M0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 db D VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 clkneg GATE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 Q m1 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net94 RESET_B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 M0 clkneg net102 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net102 m1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 m1 M0 net94 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 db D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 M0 clkpos net82 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI20 net82 db VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dlxbn_1 D GATE_N VGND VNB VPB VPWR Q Q_N
MI635 clkneg clkpos VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 Q_N net112 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 M0 clkneg net56 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI646 net112 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 Q m1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI633 clkpos GATE_N VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI18 net56 db VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 net52 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 M0 clkpos net52 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 m1 M0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 db D VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 clkpos GATE_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI647 Q_N net112 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 Q m1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI645 net112 m1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 M0 clkneg net107 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net107 m1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 m1 M0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkneg clkpos VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 db D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 M0 clkpos net87 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI20 net87 db VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dlxbn_2 D GATE_N VGND VNB VPB VPWR Q Q_N
MI635 clkneg clkpos VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 Q_N net114 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 M0 clkneg net58 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI646 net114 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 Q m1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI633 clkpos GATE_N VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI18 net58 db VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 net54 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 M0 clkpos net54 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 m1 M0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 db D VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 clkpos GATE_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI647 Q_N net114 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 Q m1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI645 net114 m1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 M0 clkneg net109 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net109 m1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 m1 M0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkneg clkpos VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 db D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 M0 clkpos net89 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI20 net89 db VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dlxbp_1 D GATE VGND VNB VPB VPWR Q Q_N
MI635 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 Q_N net114 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 M0 clkneg net58 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI646 net114 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 Q m1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI633 clkneg GATE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI18 net58 db VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 net54 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 M0 clkpos net54 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 m1 M0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 db D VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 clkneg GATE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI647 Q_N net114 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 Q m1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI645 net114 m1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 M0 clkneg net109 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net109 m1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 m1 M0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 db D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 M0 clkpos net89 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI20 net89 db VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dlxtn_1 D GATE_N VGND VNB VPB VPWR Q
MI635 clkneg clkpos VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 M0 clkneg net53 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 Q m1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI633 clkpos GATE_N VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI18 net53 db VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 net44 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 M0 clkpos net44 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 m1 M0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 db D VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 clkpos GATE_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 Q m1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 M0 clkneg net96 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net96 m1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 m1 M0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkneg clkpos VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 db D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 M0 clkpos net76 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI20 net76 db VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dlxtn_2 D GATE_N VGND VNB VPB VPWR Q
MI635 clkneg clkpos VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 M0 clkneg net51 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 Q m1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI633 clkpos GATE_N VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI18 net51 db VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 net47 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 M0 clkpos net47 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 m1 M0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 db D VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 clkpos GATE_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 Q m1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 M0 clkneg net94 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net94 m1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 m1 M0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkneg clkpos VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 db D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 M0 clkpos net74 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI20 net74 db VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dlxtn_4 D GATE_N VGND VNB VPB VPWR Q
MI635 clkneg clkpos VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 M0 clkneg net51 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 Q m1 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI633 clkpos GATE_N VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI18 net51 db VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 net47 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 M0 clkpos net47 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 m1 M0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 db D VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 clkpos GATE_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 Q m1 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 M0 clkneg net94 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net94 m1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 m1 M0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkneg clkpos VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 db D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 M0 clkpos net74 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI20 net74 db VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dlxtp_1 D GATE VGND VNB VPB VPWR Q
MI635 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 M0 clkneg net51 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 Q m1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI633 clkneg GATE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI18 net51 db VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 net47 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 M0 clkpos net47 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 m1 M0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 db D VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 clkneg GATE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 Q m1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 M0 clkneg net94 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net94 m1 VGND VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 m1 M0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 db D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 M0 clkpos net74 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI20 net74 db VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dlygate4sd1_1 A VGND VNB VPB VPWR X
MMIN1 Ab net34 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 X Ab VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 net34 net30 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI9 net30 A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Ab net34 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X Ab VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI7 net34 net30 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI8 net30 A VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dlygate4sd2_1 A VGND VNB VPB VPWR X
MMIN1 Ab net34 VGND VNB nfet_01v8 m=1 w=0.42 l=0.18 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 X Ab VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 net34 net30 VGND VNB nfet_01v8 m=1 w=0.42 l=0.18 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI9 net30 A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Ab net34 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.18 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X Ab VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI7 net34 net30 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.18 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI8 net30 A VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dlygate4sd3_1 A VGND VNB VPB VPWR X
MMIN1 Ab net34 VGND VNB nfet_01v8 m=1 w=0.42 l=0.5 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 X Ab VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 net34 net30 VGND VNB nfet_01v8 m=1 w=0.42 l=0.5 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI9 net30 A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Ab net34 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.5 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X Ab VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI7 net34 net30 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.5 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI8 net30 A VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
MMIN1 Ab net55 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 net59 Ab VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 net55 net47 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI15 net51 A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI9 net47 X VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI16 X net51 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Ab net55 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 net59 Ab VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI7 net55 net47 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI8 net47 X VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI18 X net51 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 net51 A VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dlymetal6s4s_1 A VGND VNB VPB VPWR X
MMIN1 Ab X VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 net59 Ab VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 X net47 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI15 net51 A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI9 net47 net43 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI16 net43 net51 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Ab X VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 net59 Ab VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI7 X net47 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI8 net47 net43 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI18 net43 net51 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 net51 A VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dlymetal6s6s_1 A VGND VNB VPB VPWR X
MMIN1 Ab net56 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 X Ab VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 net56 net48 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI15 net52 A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI9 net48 net44 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI16 net44 net52 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Ab net56 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X Ab VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI7 net56 net48 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI8 net48 net44 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI18 net44 net52 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 net52 A VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__ebufn_1 A TE_B VGND VNB VPB VPWR Z
MMN0 Z net35 sndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA net39 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 net39 TE_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 net35 A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP0 VPWR TE_B sndTEB VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndTEB net35 Z VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 net39 TE_B VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI5 net35 A VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__ebufn_2 A TE_B VGND VNB VPB VPWR Z
MMN0 Z net35 sndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA net39 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 net39 TE_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 net35 A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP0 VPWR TE_B sndTEB VPB pfet_01v8_hvt m=2 w=0.94 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndTEB net35 Z VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 net39 TE_B VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI5 net35 A VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__ebufn_4 A TE_B VGND VNB VPB VPWR Z
MMN0 Z net35 sndA VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA net39 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 net39 TE_B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 net35 A VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP0 VPWR TE_B sndTEB VPB pfet_01v8_hvt m=4 w=0.94 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndTEB net35 Z VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 net39 TE_B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI5 net35 A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__ebufn_8 A TE_B VGND VNB VPB VPWR Z
MMN0 Z net35 sndA VNB nfet_01v8 m=8 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA net39 VGND VNB nfet_01v8 m=8 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 net39 TE_B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 net35 A VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP0 VPWR TE_B sndTEB VPB pfet_01v8_hvt m=8 w=0.94 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndTEB net35 Z VPB pfet_01v8_hvt m=8 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 net39 TE_B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI5 net35 A VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__edfxbp_1 CLK D DE VGND VNB VPB VPWR Q Q_N
MI14 net124 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI13 S0 clkneg net124 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 net68 deneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI645 Q S0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net109 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI643 net92 S1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI639 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.75 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI644 S0 clkpos net92 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 M0 clkneg net109 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI10 net85 DE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 S1 S0 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI9 db S1 net85 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI4 deneg DE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI8 db D net68 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI21 Q_N S1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 M1 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI635 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI641 net193 S1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI642 S0 clkneg net193 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net148 DE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI646 Q S0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net168 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 M0 clkpos net168 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI18 S1 S0 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI16 net161 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI15 S0 clkpos net161 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI5 deneg DE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI7 db D net148 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI11 db S1 net141 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI12 net141 deneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI22 Q_N S1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__edfxtp_1 CLK D DE VGND VNB VPB VPWR Q
MI14 net115 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI13 S0 clkneg net115 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 net59 deneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI645 Q S0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net79 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI643 net83 S1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI639 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.75 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI644 S0 clkpos net83 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 M0 clkneg net79 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI10 net76 DE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 S1 S0 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI9 db S1 net76 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI4 deneg DE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI8 db D net59 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 M1 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI635 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI641 net175 S1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI642 S0 clkneg net175 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net172 DE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI646 Q S0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net160 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 M0 clkpos net160 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI18 S1 S0 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI16 net148 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI15 S0 clkpos net148 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI5 deneg DE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI7 db D net172 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI11 db S1 net128 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI12 net128 deneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__einvn_0 A TE_B VGND VNB VPB VPWR Z
MMN0 Z A sndA VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA net25 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 net25 TE_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP0 VPWR TE_B sndTEB VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndTEB A Z VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 net25 TE_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__einvn_1 A TE_B VGND VNB VPB VPWR Z
MMN0 Z A sndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA net25 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 net25 TE_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP0 VPWR TE_B sndTEB VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndTEB A Z VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 net25 TE_B VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__einvn_2 A TE_B VGND VNB VPB VPWR Z
MMN0 Z A sndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA TE VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 TE TE_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP0 VPWR TE_B sndTEB VPB pfet_01v8_hvt m=2 w=0.94 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndTEB A Z VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 TE TE_B VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__einvn_4 A TE_B VGND VNB VPB VPWR Z
MMN0 Z A sndA VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA TE VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 TE TE_B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP0 VPWR TE_B sndTEB VPB pfet_01v8_hvt m=4 w=0.94 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndTEB A Z VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 TE TE_B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__einvn_8 A TE_B VGND VNB VPB VPWR Z
MMN0 Z A sndA VNB nfet_01v8 m=8 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA TE VGND VNB nfet_01v8 m=8 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 TE TE_B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP0 VPWR TE_B sndTEB VPB pfet_01v8_hvt m=8 w=0.94 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndTEB A Z VPB pfet_01v8_hvt m=8 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 TE TE_B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__einvp_1 A TE VGND VNB VPB VPWR Z
MMN0 Z A sndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA TE VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 TEB TE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP0 VPWR TEB sndTEB VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndTEB A Z VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 TEB TE VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__einvp_2 A TE VGND VNB VPB VPWR Z
MMN0 Z A sndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA TE VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 TEB TE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP0 VPWR TEB sndTEB VPB pfet_01v8_hvt m=2 w=0.94 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndTEB A Z VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 TEB TE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__einvp_4 A TE VGND VNB VPB VPWR Z
MMN0 Z A sndA VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA TE VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 TEB TE VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP0 VPWR TEB sndTEB VPB pfet_01v8_hvt m=4 w=0.94 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndTEB A Z VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 TEB TE VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__einvp_8 A TE VGND VNB VPB VPWR Z
MMN0 Z A sndA VNB nfet_01v8 m=8 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA TE VGND VNB nfet_01v8 m=8 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 TEB TE VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP0 VPWR TEB sndTEB VPB pfet_01v8_hvt m=8 w=0.94 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndTEB A Z VPB pfet_01v8_hvt m=8 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 TEB TE VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__fa_1 A B CIN VGND VNB VPB VPWR COUT SUM
MMNs1s nint1 majb sumb VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 COUT majb VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 SUM sumb VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNmaj10 majb B sndNAp1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNmaj11 sndNAp1 A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNmaj30 majb CIN sndNCINn3 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNmaj31 sndNCINn3 B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNmaj20 VGND A sndNCINn3 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNs2s0 VGND A sndNAn4 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNs2s1 sndNAn4 B sndNBn4 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNs2s2 sndNBn4 CIN sumb VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNs3s0 nint1 B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNs3s1 nint1 A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNs3s2 nint1 CIN VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 COUT majb VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP3 SUM sumb VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPmaj10 VPWR A sndPAp1 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPmaj11 sndPAp1 B majb VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPmaj20 VPWR A sndPCINp3 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPmaj21 sndPCINp3 CIN majb VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPmaj31 sndPCINp3 B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPs2s0 VPWR A sndPAp4 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPs2s1 sndPAp4 B sndPBp4 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPs2s2 sndPBp4 CIN sumb VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPs3s0 pint1 B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPs3s1 pint1 A VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPs3s2 pint1 CIN VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPs1s pint1 majb sumb VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__fa_2 A B CIN VGND VNB VPB VPWR COUT SUM
MMNs1s nint1 majb sumb VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 COUT majb VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 SUM sumb VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNmaj10 majb B sndNAp1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNmaj11 sndNAp1 A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNmaj30 majb CIN nmajmid VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNmaj21 nmajmid A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNmaj20 VGND B nmajmid VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNs2s0 VGND A sndNAn4 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNs2s1 sndNAn4 B sndNBn4 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNs2s2 sndNBn4 CIN sumb VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNs3s0 nint1 A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNs3s1 nint1 B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNs3s2 nint1 CIN VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 COUT majb VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP3 SUM sumb VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPmaj10 VPWR A sndPAp1 VPB pfet_01v8_hvt m=1 w=0.63 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPmaj11 sndPAp1 B majb VPB pfet_01v8_hvt m=1 w=0.63 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPmaj20 VPWR B pmajmid VPB pfet_01v8_hvt m=1 w=0.63 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPmaj30 pmajmid CIN majb VPB pfet_01v8_hvt m=1 w=0.63 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPmaj21 pmajmid A VPWR VPB pfet_01v8_hvt m=1 w=0.63 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPs2s0 VPWR A sndPAp4 VPB pfet_01v8_hvt m=1 w=0.63 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPs2s1 sndPAp4 B sndPBp4 VPB pfet_01v8_hvt m=1 w=0.63 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPs2s2 sndPBp4 CIN sumb VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPs3s0 pint1 A VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPs3s1 pint1 B VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPs3s2 pint1 CIN VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPs1s pint1 majb sumb VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__fa_4 A B CIN VGND VNB VPB VPWR COUT SUM
MMNs1s nint1 majb sumb VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 COUT majb VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 SUM sumb VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNmaj10 majb B sndNAp1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNmaj11 sndNAp1 A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNmaj30 majb CIN nmajmid VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNmaj21 nmajmid A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNmaj20 VGND B nmajmid VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNs2s0 VGND A sndNAn4 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNs2s1 sndNAn4 B sndNBn4 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNs2s2 sndNBn4 CIN sumb VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNs3s0 nint1 A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNs3s1 nint1 B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNs3s2 nint1 CIN VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 COUT majb VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP3 SUM sumb VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPmaj10 VPWR A sndPAp1 VPB pfet_01v8_hvt m=1 w=0.63 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPmaj11 sndPAp1 B majb VPB pfet_01v8_hvt m=1 w=0.63 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPmaj20 VPWR B pmajmid VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPmaj30 pmajmid CIN majb VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPmaj21 pmajmid A VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPs2s0 VPWR A sndPAp4 VPB pfet_01v8_hvt m=1 w=0.63 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPs2s1 sndPAp4 B sndPBp4 VPB pfet_01v8_hvt m=1 w=0.63 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPs2s2 sndPBp4 CIN sumb VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPs3s0 pint1 A VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPs3s1 pint1 B VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPs3s2 pint1 CIN VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPs1s pint1 majb sumb VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__fah_1 A B CI VGND VNB VPB VPWR COUT SUM
MMIN2 COUT net195 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 SUM net123 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 CIb mid2 net195 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI5 Bb mid1 net195 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI2 CIbb mid2 net123 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 CIb mid1 net123 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 Bb B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI46 CIbb CIb VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 CIb CI VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI8 Ab2 A VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI9 Abb2 Ab2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI14 Ab1 A VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI20 Abb2 B mid1 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI21 Ab1 Bb mid1 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI24 Abb2 Bb mid2 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI25 Ab1 B mid2 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 COUT net195 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP3 SUM net123 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI4 CIb mid1 net195 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI3 Bb mid2 net195 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI1 CIbb mid1 net123 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 CIb mid2 net123 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI16 Bb B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 CIbb CIb VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 CIb CI VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI12 Ab2 A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI13 Abb2 Ab2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 Ab1 A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI22 Abb2 Bb mid1 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI23 Ab1 B mid1 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI26 Abb2 B mid2 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI27 Ab1 Bb mid2 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__fahcin_1 A B CIN VGND VNB VPB VPWR COUT SUM
MMIP3 SUM net144 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI32 Bbb Bb VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI27 Ab Bb mid2 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI26 Abb B mid2 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI22 Abb Bb mid1 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI23 Ab B mid1 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 CINb1 CIN VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI13 CINbb2 CINb2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 Abb Ab VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI12 CINb2 CIN VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI16 Bb B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 CINbb2 mid2 net144 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 Ab A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI1 CINb2 mid1 net144 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI3 Bbb mid2 COUT VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI4 CINb1 mid1 COUT VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 SUM net144 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 CINb1 mid2 COUT VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI25 Ab B mid2 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI24 Abb Bb mid2 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI21 Ab Bb mid1 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI20 Abb B mid1 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI14 CINb1 CIN VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI9 CINbb2 CINb2 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI8 CINb2 CIN VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 Ab A VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI46 Abb Ab VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 Bb B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 CINbb2 mid1 net144 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI2 CINb2 mid2 net144 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI31 Bbb mid1 COUT VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI33 Bbb Bb VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__fahcon_1 A B CI VGND VNB VPB VPWR COUT_N SUM
MMIP3 SUM net146 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI32 Bb2 B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI27 Ab Bb1 mid2 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI26 Abb B mid2 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI22 Abb Bb1 mid1 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI23 Ab B mid1 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 CIb1 CI VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI13 CIbb2 CIb2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 Abb Ab VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI12 CIb2 CI VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI16 Bb1 B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 CIb2 mid2 net146 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 Ab A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI1 CIbb2 mid1 net146 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI3 Bb2 mid2 COUT_N VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI4 CIb1 mid1 COUT_N VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 SUM net146 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 CIb1 mid2 COUT_N VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI25 Ab B mid2 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI24 Abb Bb1 mid2 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI21 Ab Bb1 mid1 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI20 Abb B mid1 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI14 CIb1 CI VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI9 CIbb2 CIb2 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI8 CIb2 CI VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 Ab A VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI46 Abb Ab VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 Bb1 B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 CIb2 mid1 net146 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI2 CIbb2 mid2 net146 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI31 Bb2 mid1 COUT_N VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI33 Bb2 B VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ENDS

.SUBCKT sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ENDS

.SUBCKT sky130_fd_sc_hd__fill_4 VGND VNB VPB VPWR
.ENDS

.SUBCKT sky130_fd_sc_hd__fill_8 VGND VNB VPB VPWR
.ENDS

.SUBCKT sky130_fd_sc_hd__ha_1 A B VGND VNB VPB VPWR COUT SUM
MMIN2 COUT majb VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 SUM sumb VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNnand0 VGND A sndNA VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNnand1 sndNA B majb VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNs1 sumb majb nint1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNs20 VGND A nint1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNs21 VGND B nint1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 COUT majb VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP3 SUM sumb VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnand0 majb A VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnand1 majb B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPs1 VPWR majb sumb VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPs20 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPs21 sndPA B sumb VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__ha_2 A B VGND VNB VPB VPWR COUT SUM
MMIN2 COUT majb VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 SUM sumb VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNnand0 VGND A sndNA VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNnand1 sndNA B majb VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNs1 sumb majb nint1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNs20 VGND A nint1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNs21 VGND B nint1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 COUT majb VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP3 SUM sumb VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnand0 majb A VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnand1 majb B VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPs1 VPWR majb sumb VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPs20 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPs21 sndPA B sumb VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__ha_4 A B VGND VNB VPB VPWR COUT SUM
MMIN2 COUT majb VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 SUM sumb VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNnand0 VGND A sndNA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNnand1 sndNA B majb VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNs1 sumb majb nint1 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNs20 VGND A nint1 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNs21 VGND B nint1 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 COUT majb VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP3 SUM sumb VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnand0 majb A VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnand1 majb B VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPs1 VPWR majb sumb VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPs20 VPWR A sndPA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPs21 sndPA B sumb VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__inv_1 A VGND VNB VPB VPWR Y
MMIN1 Y A VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Y A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
MMIN1 Y A VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Y A VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__inv_4 A VGND VNB VPB VPWR Y
MMIP1 Y A VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 Y A VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__inv_6 A VGND VNB VPB VPWR Y
MMIN1 Y A VGND VNB nfet_01v8 m=6 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Y A VPWR VPB pfet_01v8_hvt m=6 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__inv_8 A VGND VNB VPB VPWR Y
MMIP1 Y A VPWR VPB pfet_01v8_hvt m=8 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 Y A VGND VNB nfet_01v8 m=8 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__inv_12 A VGND VNB VPB VPWR Y
MMIN1 Y A VGND VNB nfet_01v8 m=12 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Y A VPWR VPB pfet_01v8_hvt m=12 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__inv_16 A VGND VNB VPB VPWR Y
MMIN1 Y A VGND VNB nfet_01v8 m=16 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Y A VPWR VPB pfet_01v8_hvt m=16 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_bleeder_1 SHORT VGND VNB VPB VPWR
MI2 net29 SHORT net25 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI3 net25 SHORT net24 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI1 VPWR SHORT net29 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI4 net24 SHORT net16 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI7 net16 SHORT VGND VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_clkbufkapwr_1 A KAPWR VGND VNB VPB VPWR X
MMIN0 Ab A VGND VNB nfet_01v8 m=1 w=0.52 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 X Ab VGND VNB nfet_01v8 m=1 w=0.52 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 Ab A KAPWR VPB pfet_01v8_hvt m=1 w=0.79 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 X Ab KAPWR VPB pfet_01v8_hvt m=1 w=0.79 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_clkbufkapwr_2 A KAPWR VGND VNB VPB VPWR X
MMIN0 Ab A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 X Ab VGND VNB nfet_01v8 m=2 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 Ab A KAPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 X Ab KAPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_clkbufkapwr_4 A KAPWR VGND VNB VPB VPWR X
MMIN0 Ab A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 X Ab VGND VNB nfet_01v8 m=4 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 Ab A KAPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 X Ab KAPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_clkbufkapwr_8 A KAPWR VGND VNB VPB VPWR X
MMIN0 Ab A VGND VNB nfet_01v8 m=2 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 X Ab VGND VNB nfet_01v8 m=8 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 Ab A KAPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 X Ab KAPWR VPB pfet_01v8_hvt m=8 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_clkbufkapwr_16 A KAPWR VGND VNB VPB VPWR X
MMIN0 Ab A VGND VNB nfet_01v8 m=4 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 X Ab VGND VNB nfet_01v8 m=16 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 Ab A KAPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 X Ab KAPWR VPB pfet_01v8_hvt m=16 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_clkinvkapwr_1 A KAPWR VGND VNB VPB VPWR Y
MMIN0 Y A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 Y A KAPWR VPB pfet_01v8_hvt m=2 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_clkinvkapwr_2 A KAPWR VGND VNB VPB VPWR Y
MMIN0 Y A VGND VNB nfet_01v8 m=2 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 Y A KAPWR VPB pfet_01v8_hvt m=3 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_clkinvkapwr_4 A KAPWR VGND VNB VPB VPWR Y
MMIN0 Y A VGND VNB nfet_01v8 m=4 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 Y A KAPWR VPB pfet_01v8_hvt m=6 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_clkinvkapwr_8 A KAPWR VGND VNB VPB VPWR Y
MMIN0 Y A VGND VNB nfet_01v8 m=8 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 Y A KAPWR VPB pfet_01v8_hvt m=12 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_clkinvkapwr_16 A KAPWR VGND VNB VPB VPWR Y
MMIN0 Y A VGND VNB nfet_01v8 m=16 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 Y A KAPWR VPB pfet_01v8_hvt m=24 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_decapkapwr_3 KAPWR VGND VNB VPB VPWR
MI1 VGND KAPWR VGND VNB nfet_01v8 m=1 w=0.55 l=0.59 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI2 KAPWR VGND KAPWR VPB pfet_01v8_hvt m=1 w=0.87 l=0.59 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_decapkapwr_4 KAPWR VGND VNB VPB VPWR
MI1 VGND KAPWR VGND VNB nfet_01v8 m=1 w=0.55 l=1.05 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI2 KAPWR VGND KAPWR VPB pfet_01v8_hvt m=1 w=0.87 l=1.05 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_decapkapwr_6 KAPWR VGND VNB VPB VPWR
MI1 VGND KAPWR VGND VNB nfet_01v8 m=1 w=0.55 l=1.97 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI2 KAPWR VGND KAPWR VPB pfet_01v8_hvt m=1 w=0.87 l=1.97 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_decapkapwr_8 KAPWR VGND VNB VPB VPWR
MI1 VGND KAPWR VGND VNB nfet_01v8 m=1 w=0.55 l=2.89 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI2 KAPWR VGND KAPWR VPB pfet_01v8_hvt m=1 w=0.87 l=2.89 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_decapkapwr_12 KAPWR VGND VNB VPB VPWR
MI1 VGND KAPWR VGND VNB nfet_01v8 m=1 w=0.55 l=4.73 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI2 KAPWR VGND KAPWR VPB pfet_01v8_hvt m=1 w=0.87 l=4.73 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_inputiso0n_1 A SLEEP_B VGND VNB VPB VPWR X
MI14 X net36 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 net36 A sndA VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI13 sndA SLEEP_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 net36 SLEEP_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 X net36 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 net36 A VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_inputiso0p_1 A SLEEP VGND VNB VPB VPWR X
MI8 net36 A VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI7 net36 sleepb VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI20 X net36 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 sleepb SLEEP VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI10 net36 sleepb sndA VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI21 X net36 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI18 sleepb SLEEP VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI11 sndA A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_inputiso1n_1 A SLEEP_B VGND VNB VPB VPWR X
MI23 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI8 VPWR net44 X VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 net56 SLEEP_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI7 sndPA net56 net44 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 net56 SLEEP_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI25 net44 A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 X net44 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI9 net44 net56 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_inputiso1p_1 A SLEEP VGND VNB VPB VPWR X
MMP0 VPWR SLEEP sndPA VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI7 sndPA A net36 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI15 VPWR net36 X VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI10 net36 A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI16 net36 SLEEP VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI14 X net36 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_inputisolatch_1 D SLEEP_B VGND VNB VPB VPWR Q
MI677 Q s0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 sleepneg sleeppos VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI674 net39 s0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 s0 sleepneg net49 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI20 net49 D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 s0 sleeppos net38 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net38 net39 VGND VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI670 sleeppos SLEEP_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI643 sleeppos SLEEP_B VPWR VPB pfet_01v8_hvt m=1 w=0.55 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI635 sleepneg sleeppos VPWR VPB pfet_01v8_hvt m=1 w=0.55 l=0.15
+ mult=1 sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063
+ perim=1.14
MI662 net86 net39 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 s0 sleepneg net86 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net39 s0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI663 Q s0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 s0 sleeppos net69 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI18 net69 D VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_isobufsrc_1 A SLEEP VGND VNB VPB VPWR X
MMP0 VPWR SLEEP sndPA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA Ab X VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Ab A VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 X SLEEP VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 X Ab VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 Ab A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_isobufsrc_2 A SLEEP VGND VNB VPB VPWR X
MMP0 VPWR SLEEP sndPA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA Ab X VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Ab A VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 X SLEEP VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 X Ab VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 Ab A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_isobufsrc_4 A SLEEP VGND VNB VPB VPWR X
MMP0 VPWR SLEEP sndPA VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA Ab X VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Ab A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 X SLEEP VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 X Ab VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 Ab A VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_isobufsrc_8 A SLEEP VGND VNB VPB VPWR X
MMP0 VPWR Ab sndPA VPB pfet_01v8_hvt m=8 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA SLEEP X VPB pfet_01v8_hvt m=8 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Ab A VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 X SLEEP VGND VNB nfet_01v8 m=8 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 X Ab VGND VNB nfet_01v8 m=8 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 Ab A VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_isobufsrc_16 A SLEEP VGND VNB VPB VPWR X
MMP0 VPWR Ab sndPA VPB pfet_01v8_hvt m=16 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA SLEEP X VPB pfet_01v8_hvt m=16 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Ab A VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 X SLEEP VGND VNB nfet_01v8 m=16 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 X Ab VGND VNB nfet_01v8 m=16 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 Ab A VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_isobufsrckapwr_16 A SLEEP KAPWR VGND VNB VPB VPWR X
MMP0 VPWR SLEEP sndPA VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA net58 net66 VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 net58 A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 Ab net66 KAPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI9 X Ab KAPWR VPB pfet_01v8_hvt m=16 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 net66 SLEEP VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 net66 net58 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 net58 A VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 Ab net66 VGND VNB nfet_01v8 m=4 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI8 X Ab VGND VNB nfet_01v8 m=16 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_lsbuf_lh_hl_isowell_tap_1 A VGND VPB VPWRIN VPWR X
M1000 X a_1028_32# VPWR VPB pfet_01v8_hvt w=790000u l=150000u
+ ad=2.1725e+11p pd=2.13e+06u as=4.7795e+11p ps=4.37e+06u
M1001 VPWR a_620_911# a_714_58# VPB pfet_01v8_hvt w=790000u l=150000u
+ ad=0p pd=0u as=2.1725e+11p ps=2.13e+06u
M1002 a_1028_32# a_620_911# VPWR VPB pfet_01v8_hvt w=790000u l=150000u
+ ad=2.133e+11p pd=2.12e+06u as=0p ps=0u
M1003 X a_1028_32# VGND VGND nfet_01v8 w=650000u l=150000u
+ ad=1.8525e+11p pd=1.87e+06u as=1.4178e+12p ps=1.319e+07u
M1004 a_620_911# a_505_297# VGND VGND nfet_01v8 w=650000u l=150000u
+ ad=3.64e+11p pd=3.72e+06u as=0p ps=0u
M1005 a_714_58# A VGND VGND nfet_01v8 w=650000u l=150000u ad=3.64e+11p
+ pd=3.72e+06u as=0p ps=0u
M1006 a_714_58# A VGND VGND nfet_01v8 w=650000u l=150000u ad=0p pd=0u
+ as=0p ps=0u
M1007 VGND a_505_297# a_620_911# VGND nfet_01v8 w=650000u l=150000u
+ ad=0p pd=0u as=0p ps=0u
M1008 a_1028_32# a_620_911# VGND VGND nfet_01v8 w=650000u l=150000u
+ ad=1.7225e+11p pd=1.83e+06u as=0p ps=0u
M1009 a_505_297# A VPWRIN VPWRIN pfet_01v8_hvt w=1e+06u l=150000u
+ ad=2.75e+11p pd=2.55e+06u as=2.75e+11p ps=2.55e+06u
M1010 a_505_297# A VGND VGND nfet_01v8 w=420000u l=150000u
+ ad=1.113e+11p pd=1.37e+06u as=0p ps=0u
M1011 VGND A a_714_58# VGND nfet_01v8 w=650000u l=150000u ad=0p pd=0u
+ as=0p ps=0u
M1012 VGND A a_714_58# VGND nfet_01v8 w=650000u l=150000u ad=0p pd=0u
+ as=0p ps=0u
M1013 VGND a_505_297# a_620_911# VGND nfet_01v8 w=650000u l=150000u
+ ad=0p pd=0u as=0p ps=0u
M1014 a_620_911# a_505_297# VGND VGND nfet_01v8 w=650000u l=150000u
+ ad=0p pd=0u as=0p ps=0u
M1015 VPWR a_714_58# a_620_911# VPB pfet_01v8_hvt w=790000u l=150000u
+ ad=0p pd=0u as=2.1725e+11p ps=2.13e+06u
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_lsbuf_lh_hl_isowell_tap_2 A VGND VPB VPWRIN VPWR X
M1000 VPWR a_620_911# a_714_47# VPB pfet_01v8_hvt w=790000u l=150000u
+ ad=8.352e+11p pd=7.41e+06u as=2.1725e+11p ps=2.13e+06u
M1001 a_1032_911# a_620_911# VPWR VPB pfet_01v8_hvt w=790000u
+ l=150000u ad=2.133e+11p pd=2.12e+06u as=0p ps=0u
M1002 a_620_911# a_505_297# VGND VGND nfet_01v8 w=650000u l=150000u
+ ad=3.64e+11p pd=3.72e+06u as=1.62905e+12p ps=1.514e+07u
M1003 a_714_47# A VGND VGND nfet_01v8 w=650000u l=150000u ad=3.64e+11p
+ pd=3.72e+06u as=0p ps=0u
M1004 a_714_47# A VGND VGND nfet_01v8 w=650000u l=150000u ad=0p pd=0u
+ as=0p ps=0u
M1005 X a_1032_911# VGND VGND nfet_01v8 w=650000u l=150000u
+ ad=2.405e+11p pd=2.04e+06u as=0p ps=0u
M1006 VPWR a_1032_911# X VPB pfet_01v8_hvt w=1e+06u l=150000u ad=0p
+ pd=0u as=3.7e+11p ps=2.74e+06u
M1007 VGND A a_714_47# VGND nfet_01v8 w=650000u l=150000u ad=0p pd=0u
+ as=0p ps=0u
M1008 VGND a_505_297# a_620_911# VGND nfet_01v8 w=650000u l=150000u
+ ad=0p pd=0u as=0p ps=0u
M1009 a_1032_911# a_620_911# VGND VGND nfet_01v8 w=650000u l=150000u
+ ad=1.7225e+11p pd=1.83e+06u as=0p ps=0u
M1010 VGND A a_714_47# VGND nfet_01v8 w=650000u l=150000u ad=0p pd=0u
+ as=0p ps=0u
M1011 a_505_297# A VPWRIN VPWRIN pfet_01v8_hvt w=1e+06u l=150000u
+ ad=2.75e+11p pd=2.55e+06u as=2.75e+11p ps=2.55e+06u
M1012 a_505_297# A VGND VGND nfet_01v8 w=420000u l=150000u
+ ad=1.113e+11p pd=1.37e+06u as=0p ps=0u
M1013 X a_1032_911# VPWR VPB pfet_01v8_hvt w=1e+06u l=150000u ad=0p
+ pd=0u as=0p ps=0u
M1014 VGND a_1032_911# X VGND nfet_01v8 w=650000u l=150000u ad=0p
+ pd=0u as=0p ps=0u
M1015 VGND a_505_297# a_620_911# VGND nfet_01v8 w=650000u l=150000u
+ ad=0p pd=0u as=0p ps=0u
M1016 a_620_911# a_505_297# VGND VGND nfet_01v8 w=650000u l=150000u
+ ad=0p pd=0u as=0p ps=0u
M1017 VPWR a_714_47# a_620_911# VPB pfet_01v8_hvt w=790000u l=150000u
+ ad=0p pd=0u as=2.1725e+11p ps=2.13e+06u
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_lsbuf_lh_hl_isowell_tap_4 A VGND VPB VPWRIN VPWR X
M1000 VPWR a_620_911# a_714_47# VPB pfet_01v8_hvt w=790000u l=150000u
+ ad=1.1152e+12p pd=9.97e+06u as=2.1725e+11p ps=2.13e+06u
M1001 a_1032_911# a_620_911# VPWR VPB pfet_01v8_hvt w=790000u
+ l=150000u ad=2.133e+11p pd=2.12e+06u as=0p ps=0u
M1002 X a_1032_911# VPWR VPB pfet_01v8_hvt w=1e+06u l=150000u
+ ad=6.5e+11p pd=5.3e+06u as=0p ps=0u
M1003 a_620_911# a_505_297# VGND VGND nfet_01v8 w=650000u l=150000u
+ ad=3.64e+11p pd=3.72e+06u as=1.81105e+12p ps=1.7e+07u
M1004 a_714_47# A VGND VGND nfet_01v8 w=650000u l=150000u ad=3.64e+11p
+ pd=3.72e+06u as=0p ps=0u
M1005 a_714_47# A VGND VGND nfet_01v8 w=650000u l=150000u ad=0p pd=0u
+ as=0p ps=0u
M1006 X a_1032_911# VGND VGND nfet_01v8 w=650000u l=150000u
+ ad=4.225e+11p pd=3.9e+06u as=0p ps=0u
M1007 X a_1032_911# VGND VGND nfet_01v8 w=650000u l=150000u ad=0p
+ pd=0u as=0p ps=0u
M1008 VPWR a_1032_911# X VPB pfet_01v8_hvt w=1e+06u l=150000u ad=0p
+ pd=0u as=0p ps=0u
M1009 VGND A a_714_47# VGND nfet_01v8 w=650000u l=150000u ad=0p pd=0u
+ as=0p ps=0u
M1010 VGND a_505_297# a_620_911# VGND nfet_01v8 w=650000u l=150000u
+ ad=0p pd=0u as=0p ps=0u
M1011 a_1032_911# a_620_911# VGND VGND nfet_01v8 w=650000u l=150000u
+ ad=1.7225e+11p pd=1.83e+06u as=0p ps=0u
M1012 VGND A a_714_47# VGND nfet_01v8 w=650000u l=150000u ad=0p pd=0u
+ as=0p ps=0u
M1013 a_505_297# A VPWRIN VPWRIN pfet_01v8_hvt w=1e+06u l=150000u
+ ad=2.75e+11p pd=2.55e+06u as=2.75e+11p ps=2.55e+06u
M1014 a_505_297# A VGND VGND nfet_01v8 w=420000u l=150000u
+ ad=1.113e+11p pd=1.37e+06u as=0p ps=0u
M1015 X a_1032_911# VPWR VPB pfet_01v8_hvt w=1e+06u l=150000u ad=0p
+ pd=0u as=0p ps=0u
M1016 VPWR a_1032_911# X VPB pfet_01v8_hvt w=1e+06u l=150000u ad=0p
+ pd=0u as=0p ps=0u
M1017 VGND a_1032_911# X VGND nfet_01v8 w=650000u l=150000u ad=0p
+ pd=0u as=0p ps=0u
M1018 VGND a_1032_911# X VGND nfet_01v8 w=650000u l=150000u ad=0p
+ pd=0u as=0p ps=0u
M1019 VGND a_505_297# a_620_911# VGND nfet_01v8 w=650000u l=150000u
+ ad=0p pd=0u as=0p ps=0u
M1020 a_620_911# a_505_297# VGND VGND nfet_01v8 w=650000u l=150000u
+ ad=0p pd=0u as=0p ps=0u
M1021 VPWR a_714_47# a_620_911# VPB pfet_01v8_hvt w=790000u l=150000u
+ ad=0p pd=0u as=2.1725e+11p ps=2.13e+06u
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_lsbuf_lh_isowell_4 A LOWLVPWR VGND VNB VPB VPWR X
MI2 net72 cross1 VPWR VPB pfet_01v8_hvt m=1 w=0.79 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI3 cross1 net72 VPWR VPB pfet_01v8_hvt m=1 w=0.79 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI20 Ab A LOWLVPWR LOWLVPWR pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI24 X net60 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI28 net60 cross1 VPWR VPB pfet_01v8_hvt m=1 w=0.79 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI5 cross1 Ab VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI4 net72 A VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI23 Ab A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI25 X net60 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI29 net60 cross1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_lsbuf_lh_isowell_tap_1 A LOWLVPWR VGND VPB VPWR X
M1000 X a_1028_32# VPWR VPB pfet_01v8_hvt w=790000u l=150000u
+ ad=2.1725e+11p pd=2.13e+06u as=4.7795e+11p ps=4.37e+06u
M1001 VPWR a_620_911# a_714_58# VPB pfet_01v8_hvt w=790000u l=150000u
+ ad=0p pd=0u as=2.1725e+11p ps=2.13e+06u
M1002 a_1028_32# a_620_911# VPWR VPB pfet_01v8_hvt w=790000u l=150000u
+ ad=2.133e+11p pd=2.12e+06u as=0p ps=0u
M1003 X a_1028_32# VGND VGND nfet_01v8 w=650000u l=150000u
+ ad=1.8525e+11p pd=1.87e+06u as=1.4178e+12p ps=1.319e+07u
M1004 a_620_911# a_505_297# VGND VGND nfet_01v8 w=650000u l=150000u
+ ad=3.64e+11p pd=3.72e+06u as=0p ps=0u
M1005 a_714_58# A VGND VGND nfet_01v8 w=650000u l=150000u ad=3.64e+11p
+ pd=3.72e+06u as=0p ps=0u
M1006 a_714_58# A VGND VGND nfet_01v8 w=650000u l=150000u ad=0p pd=0u
+ as=0p ps=0u
M1007 VGND a_505_297# a_620_911# VGND nfet_01v8 w=650000u l=150000u
+ ad=0p pd=0u as=0p ps=0u
M1008 a_1028_32# a_620_911# VGND VGND nfet_01v8 w=650000u l=150000u
+ ad=1.7225e+11p pd=1.83e+06u as=0p ps=0u
M1009 a_505_297# A LOWLVPWR LOWLVPWR pfet_01v8_hvt w=1e+06u l=150000u
+ ad=2.75e+11p pd=2.55e+06u as=2.75e+11p ps=2.55e+06u
M1010 a_505_297# A VGND VGND nfet_01v8 w=420000u l=150000u
+ ad=1.113e+11p pd=1.37e+06u as=0p ps=0u
M1011 VGND A a_714_58# VGND nfet_01v8 w=650000u l=150000u ad=0p pd=0u
+ as=0p ps=0u
M1012 VGND A a_714_58# VGND nfet_01v8 w=650000u l=150000u ad=0p pd=0u
+ as=0p ps=0u
M1013 VGND a_505_297# a_620_911# VGND nfet_01v8 w=650000u l=150000u
+ ad=0p pd=0u as=0p ps=0u
M1014 a_620_911# a_505_297# VGND VGND nfet_01v8 w=650000u l=150000u
+ ad=0p pd=0u as=0p ps=0u
M1015 VPWR a_714_58# a_620_911# VPB pfet_01v8_hvt w=790000u l=150000u
+ ad=0p pd=0u as=2.1725e+11p ps=2.13e+06u
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_lsbuf_lh_isowell_tap_2 A LOWLVPWR VGND VPB VPWR X
M1000 VPWR a_620_911# a_714_47# VPB pfet_01v8_hvt w=790000u l=150000u
+ ad=8.352e+11p pd=7.41e+06u as=2.1725e+11p ps=2.13e+06u
M1001 a_1032_911# a_620_911# VPWR VPB pfet_01v8_hvt w=790000u
+ l=150000u ad=2.133e+11p pd=2.12e+06u as=0p ps=0u
M1002 a_620_911# a_505_297# VGND VGND nfet_01v8 w=650000u l=150000u
+ ad=3.64e+11p pd=3.72e+06u as=1.62905e+12p ps=1.514e+07u
M1003 a_714_47# A VGND VGND nfet_01v8 w=650000u l=150000u ad=3.64e+11p
+ pd=3.72e+06u as=0p ps=0u
M1004 a_714_47# A VGND VGND nfet_01v8 w=650000u l=150000u ad=0p pd=0u
+ as=0p ps=0u
M1005 X a_1032_911# VGND VGND nfet_01v8 w=650000u l=150000u
+ ad=2.405e+11p pd=2.04e+06u as=0p ps=0u
M1006 VPWR a_1032_911# X VPB pfet_01v8_hvt w=1e+06u l=150000u ad=0p
+ pd=0u as=3.7e+11p ps=2.74e+06u
M1007 VGND A a_714_47# VGND nfet_01v8 w=650000u l=150000u ad=0p pd=0u
+ as=0p ps=0u
M1008 VGND a_505_297# a_620_911# VGND nfet_01v8 w=650000u l=150000u
+ ad=0p pd=0u as=0p ps=0u
M1009 a_1032_911# a_620_911# VGND VGND nfet_01v8 w=650000u l=150000u
+ ad=1.7225e+11p pd=1.83e+06u as=0p ps=0u
M1010 VGND A a_714_47# VGND nfet_01v8 w=650000u l=150000u ad=0p pd=0u
+ as=0p ps=0u
M1011 a_505_297# A LOWLVPWR LOWLVPWR pfet_01v8_hvt w=1e+06u l=150000u
+ ad=2.75e+11p pd=2.55e+06u as=2.75e+11p ps=2.55e+06u
M1012 a_505_297# A VGND VGND nfet_01v8 w=420000u l=150000u
+ ad=1.113e+11p pd=1.37e+06u as=0p ps=0u
M1013 X a_1032_911# VPWR VPB pfet_01v8_hvt w=1e+06u l=150000u ad=0p
+ pd=0u as=0p ps=0u
M1014 VGND a_1032_911# X VGND nfet_01v8 w=650000u l=150000u ad=0p
+ pd=0u as=0p ps=0u
M1015 VGND a_505_297# a_620_911# VGND nfet_01v8 w=650000u l=150000u
+ ad=0p pd=0u as=0p ps=0u
M1016 a_620_911# a_505_297# VGND VGND nfet_01v8 w=650000u l=150000u
+ ad=0p pd=0u as=0p ps=0u
M1017 VPWR a_714_47# a_620_911# VPB pfet_01v8_hvt w=790000u l=150000u
+ ad=0p pd=0u as=2.1725e+11p ps=2.13e+06u
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_lsbuf_lh_isowell_tap_4 A LOWLVPWR VGND VPB VPWR X
M1000 VPWR a_620_911# a_714_47# VPB pfet_01v8_hvt w=790000u l=150000u
+ ad=1.1152e+12p pd=9.97e+06u as=2.1725e+11p ps=2.13e+06u
M1001 a_1032_911# a_620_911# VPWR VPB pfet_01v8_hvt w=790000u
+ l=150000u ad=2.133e+11p pd=2.12e+06u as=0p ps=0u
M1002 X a_1032_911# VPWR VPB pfet_01v8_hvt w=1e+06u l=150000u
+ ad=6.5e+11p pd=5.3e+06u as=0p ps=0u
M1003 a_620_911# a_505_297# VGND VGND nfet_01v8 w=650000u l=150000u
+ ad=3.64e+11p pd=3.72e+06u as=1.81105e+12p ps=1.7e+07u
M1004 a_714_47# A VGND VGND nfet_01v8 w=650000u l=150000u ad=3.64e+11p
+ pd=3.72e+06u as=0p ps=0u
M1005 a_714_47# A VGND VGND nfet_01v8 w=650000u l=150000u ad=0p pd=0u
+ as=0p ps=0u
M1006 X a_1032_911# VGND VGND nfet_01v8 w=650000u l=150000u
+ ad=4.225e+11p pd=3.9e+06u as=0p ps=0u
M1007 X a_1032_911# VGND VGND nfet_01v8 w=650000u l=150000u ad=0p
+ pd=0u as=0p ps=0u
M1008 VPWR a_1032_911# X VPB pfet_01v8_hvt w=1e+06u l=150000u ad=0p
+ pd=0u as=0p ps=0u
M1009 VGND A a_714_47# VGND nfet_01v8 w=650000u l=150000u ad=0p pd=0u
+ as=0p ps=0u
M1010 VGND a_505_297# a_620_911# VGND nfet_01v8 w=650000u l=150000u
+ ad=0p pd=0u as=0p ps=0u
M1011 a_1032_911# a_620_911# VGND VGND nfet_01v8 w=650000u l=150000u
+ ad=1.7225e+11p pd=1.83e+06u as=0p ps=0u
M1012 VGND A a_714_47# VGND nfet_01v8 w=650000u l=150000u ad=0p pd=0u
+ as=0p ps=0u
M1013 a_505_297# A LOWLVPWR LOWLVPWR pfet_01v8_hvt w=1e+06u l=150000u
+ ad=2.75e+11p pd=2.55e+06u as=2.75e+11p ps=2.55e+06u
M1014 a_505_297# A VGND VGND nfet_01v8 w=420000u l=150000u
+ ad=1.113e+11p pd=1.37e+06u as=0p ps=0u
M1015 X a_1032_911# VPWR VPB pfet_01v8_hvt w=1e+06u l=150000u ad=0p
+ pd=0u as=0p ps=0u
M1016 VPWR a_1032_911# X VPB pfet_01v8_hvt w=1e+06u l=150000u ad=0p
+ pd=0u as=0p ps=0u
M1017 VGND a_1032_911# X VGND nfet_01v8 w=650000u l=150000u ad=0p
+ pd=0u as=0p ps=0u
M1018 VGND a_1032_911# X VGND nfet_01v8 w=650000u l=150000u ad=0p
+ pd=0u as=0p ps=0u
M1019 VGND a_505_297# a_620_911# VGND nfet_01v8 w=650000u l=150000u
+ ad=0p pd=0u as=0p ps=0u
M1020 a_620_911# a_505_297# VGND VGND nfet_01v8 w=650000u l=150000u
+ ad=0p pd=0u as=0p ps=0u
M1021 VPWR a_714_47# a_620_911# VPB pfet_01v8_hvt w=790000u l=150000u
+ ad=0p pd=0u as=2.1725e+11p ps=2.13e+06u
.ENDS

.SUBCKT sky130_fd_sc_hd__macro_sparecell VGND VNB VPB VPWR LO
XI1 VGND VNB VPB VPWR net59 LO / sky130_fd_sc_hd__conb_1
XI2 LO LO VGND VNB VPB VPWR nd2right / sky130_fd_sc_hd__nand2_2
XI3 LO LO VGND VNB VPB VPWR nd2left / sky130_fd_sc_hd__nand2_2
XI4 nd2right nd2right VGND VNB VPB VPWR nor2right / sky130_fd_sc_hd__nor2_2
XI5 nd2left nd2left VGND VNB VPB VPWR nor2left / sky130_fd_sc_hd__nor2_2
XI6 nor2right VGND VNB VPB VPWR invright / sky130_fd_sc_hd__inv_2
XI7 nor2left VGND VNB VPB VPWR invleft / sky130_fd_sc_hd__inv_2
.ENDS

.SUBCKT sky130_fd_sc_hd__maj3_1 A B C VGND VNB VPB VPWR X
MMIN2 X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN10 y B sndNBa VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN11 sndNBa A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN20 y B sndNBc VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN21 sndNBc C VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN30 y C sndNCa VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN31 sndNCa A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP10 VPWR A sndPAb VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP11 sndPAb B y VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP20 VPWR C sndPCb VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP21 sndPCb B y VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP30 VPWR A sndPAc VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP31 sndPAc C y VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__maj3_2 A B C VGND VNB VPB VPWR X
MMIN2 X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN10 y B sndNBa VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN11 sndNBa A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN20 y B sndNBc VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN21 sndNBc C VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN30 y C sndNCa VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN31 sndNCa A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP10 VPWR A sndPAb VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP11 sndPAb B y VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP20 VPWR C sndPCb VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP21 sndPCb B y VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP30 VPWR A sndPAc VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP31 sndPAc C y VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__maj3_4 A B C VGND VNB VPB VPWR X
MMIN2 X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN10 y B sndNBa VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN11 sndNBa A VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN20 y B sndNBc VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN21 sndNBc C VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN30 y C sndNCa VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN31 sndNCa A VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP10 VPWR A sndPAb VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP11 sndPAb B y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP20 VPWR C sndPCb VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP21 sndPCb B y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP30 VPWR A sndPAc VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP31 sndPAc C y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
MMNA00 xb A0 smdNA0 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA01 smdNA0 Sb VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA10 xb A1 sndNA1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA11 sndNA1 S VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 Sb S VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 X xb VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA00 VPWR S sndPS VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA01 sndPS A0 xb VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA10 VPWR Sb sndPSb VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA11 sndPSb A1 xb VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Sb S VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X xb VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__mux2_2 A0 A1 S VGND VNB VPB VPWR X
MMNA00 xb A0 smdNA0 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA01 smdNA0 Sb VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA10 xb A1 sndNA1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA11 sndNA1 S VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 Sb S VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 X xb VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA00 VPWR S sndPS VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA01 sndPS A0 xb VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA10 VPWR Sb sndPSb VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA11 sndPSb A1 xb VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Sb S VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X xb VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__mux2_4 A0 A1 S VGND VNB VPB VPWR X
MMNA00 xb A0 smdNA0 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA01 smdNA0 Sb VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA10 xb A1 sndNA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA11 sndNA1 S VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 Sb S VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 X xb VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA00 VPWR S sndPS VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA01 sndPS A0 xb VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA10 VPWR Sb sndPSb VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA11 sndPSb A1 xb VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Sb S VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X xb VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__mux2_8 A0 A1 S VGND VNB VPB VPWR X
MMNA00 xb A0 smdNA0 VNB nfet_01v8 m=2 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA01 smdNA0 Sb VGND VNB nfet_01v8 m=2 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA10 xb A1 sndNA1 VNB nfet_01v8 m=2 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA11 sndNA1 S VGND VNB nfet_01v8 m=2 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 Sb S VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 X xb VGND VNB nfet_01v8 m=8 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA00 VPWR S sndPS VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA01 sndPS A0 xb VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA10 VPWR Sb sndPSb VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA11 sndPSb A1 xb VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Sb S VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X xb VPWR VPB pfet_01v8_hvt m=8 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__mux2i_1 A0 A1 S VGND VNB VPB VPWR Y
MMNA00 Y A0 smdNA0 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA01 smdNA0 Sb VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA10 Y A1 sndNA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA11 sndNA1 S VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 Sb S VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA00 VPWR S sndPS VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA01 sndPS A0 Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA10 VPWR Sb sndPSb VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA11 sndPSb A1 Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Sb S VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__mux2i_2 A0 A1 S VGND VNB VPB VPWR Y
MMNA00 Y A0 smdNA0 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA01 smdNA0 Sb VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA10 Y A1 sndNA1 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA11 sndNA1 S VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 Sb S VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA00 VPWR S sndPS VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA01 sndPS A0 Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA10 VPWR Sb sndPSb VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA11 sndPSb A1 Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Sb S VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__mux2i_4 A0 A1 S VGND VNB VPB VPWR Y
MMNA00 Y A0 smdNA0 VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA01 smdNA0 Sb VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA10 Y A1 sndNA1 VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA11 sndNA1 S VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 Sb S VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA00 VPWR S sndPS VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA01 sndPS A0 Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA10 VPWR Sb sndPSb VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA11 sndPSb A1 Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Sb S VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__mux4_1 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
MMNA00 sndNS0ba0 S0b xlowb VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMNA01 VGND A0 sndNS0ba0 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMNA10 sndNS0a1 S0 xlowb VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMNA11 VGND A1 sndNS0a1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMNA20 sndNS0ba2 S0b xhib VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMNA21 VGND A2 sndNS0ba2 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMNA30 sndNS0a3 S0 xhib VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMNA31 VGND A3 sndNS0a3 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMNs1o xb S1b xlowb VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMNs2o xb S1 xhib VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMIN1 VGND S1 S1b VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMIN2 VGND S0 S0b VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMIN4 VGND xb X VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMPA00 sndPA0a0 A0 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMPA01 xlowb S0 sndPA0a0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMPA10 sndPA1a1 A1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMPA11 xlowb S0b sndPA1a1 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMPA20 sndPA2a2 A2 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMPA21 xhib S0 sndPA2a2 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMPA30 sndPA3a3 A3 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMPA31 xhib S0b sndPA3a3 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMPs1o xb S1 xlowb VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMPs2o xb S1b xhib VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMIP1 VPWR S1 S1b VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMIP2 VPWR S0 S0b VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMIP4 VPWR xb X VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
.ENDS

.SUBCKT sky130_fd_sc_hd__mux4_2 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
MMNA00 sndNS0ba0 S0b xlowb VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMNA01 VGND A0 sndNS0ba0 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMNA10 sndNS0a1 S0 xlowb VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMNA11 VGND A1 sndNS0a1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMNA20 sndNS0ba2 S0b xhib VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMNA21 VGND A2 sndNS0ba2 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMNA30 sndNS0a3 S0 xhib VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMNA31 VGND A3 sndNS0a3 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMNs1o xb S1b xlowb VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMNs2o xb S1 xhib VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMIN1 VGND S1 S1b VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMIN2 VGND S0 S0b VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMIN4 VGND xb X VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMPA00 sndPA0a0 A0 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMPA01 xlowb S0 sndPA0a0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMPA10 sndPA1a1 A1 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMPA11 xlowb S0b sndPA1a1 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMPA20 sndPA2a2 A2 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMPA21 xhib S0 sndPA2a2 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMPA30 sndPA3a3 A3 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMPA31 xhib S0b sndPA3a3 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMPs1o xb S1 xlowb VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMPs2o xb S1b xhib VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMIP1 VPWR S1 S1b VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMIP2 VPWR S0 S0b VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMIP4 VPWR xb X VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
.ENDS

.SUBCKT sky130_fd_sc_hd__mux4_4 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
MMNA00 sndNS0ba0 S0b xlowb VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMNA01 VGND A0 sndNS0ba0 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMNA10 sndNS0a1 S0 xlowb VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMNA11 VGND A1 sndNS0a1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMNA20 sndNS0ba2 S0b xhib VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMNA21 VGND A2 sndNS0ba2 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMNA30 sndNS0a3 S0 xhib VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMNA31 VGND A3 sndNS0a3 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMNs1o xb S1b xlowb VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMNs2o xb S1 xhib VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMIN1 VGND S1 S1b VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMIN2 VGND S0 S0b VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMIN4 VGND xb X VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMPA00 sndPA0a0 A0 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMPA01 xlowb S0 sndPA0a0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMPA10 sndPA1a1 A1 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMPA11 xlowb S0b sndPA1a1 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMPA20 sndPA2a2 A2 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMPA21 xhib S0 sndPA2a2 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMPA30 sndPA3a3 A3 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMPA31 xhib S0b sndPA3a3 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMPs1o xb S1 xlowb VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMPs2o xb S1b xhib VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMIP1 VPWR S1 S1b VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMIP2 VPWR S0 S0b VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMIP4 VPWR xb X VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
.ENDS

.SUBCKT sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
MMP0 Y A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 Y B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A sndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nand2_2 A B VGND VNB VPB VPWR Y
MMP0 Y A VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 Y B VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A sndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nand2_4 A B VGND VNB VPB VPWR Y
MMP0 Y A VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 Y B VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A sndA VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nand2_8 A B VGND VNB VPB VPWR Y
MMP0 Y A VPWR VPB pfet_01v8_hvt m=8 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 Y B VPWR VPB pfet_01v8_hvt m=8 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A sndA VNB nfet_01v8 m=8 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B VGND VNB nfet_01v8 m=8 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nand2b_1 A_N B VGND VNB VPB VPWR Y
MMP0 Y A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 Y B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 A A_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A sndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 A A_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nand2b_2 A_N B VGND VNB VPB VPWR Y
MMP0 Y A VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 Y B VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 A A_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A sndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 A A_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nand2b_4 A_N B VGND VNB VPB VPWR Y
MMP0 Y A VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 Y B VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 A A_N VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A sndA VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 A A_N VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nand3_1 A B C VGND VNB VPB VPWR Y
MMP0 Y A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 Y B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 Y C VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A sndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B sndB VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 sndB C VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nand3_2 A B C VGND VNB VPB VPWR Y
MMP0 Y A VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 Y B VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 Y C VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A sndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B sndB VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 sndB C VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nand3_4 A B C VGND VNB VPB VPWR Y
MMP0 Y A VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 Y B VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 Y C VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A sndA VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B sndB VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 sndB C VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nand3b_1 A_N B C VGND VNB VPB VPWR Y
MMP0 Y A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 Y B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 Y C VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 A A_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A sndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B sndB VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 sndB C VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 A A_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nand3b_2 A_N B C VGND VNB VPB VPWR Y
MMP0 Y A VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 Y B VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 Y C VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 A A_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A sndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B sndB VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 sndB C VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 A A_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nand3b_4 A_N B C VGND VNB VPB VPWR Y
MMP0 Y A VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 Y B VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 Y C VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 A A_N VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A sndA VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B sndB VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 sndB C VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 A A_N VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nand4_1 A B C D VGND VNB VPB VPWR Y
MMP0 Y A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 Y B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 Y D VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 Y C VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A sndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B sndB VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 sndB C sndC VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 sndC D VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nand4_2 A B C D VGND VNB VPB VPWR Y
MMP0 Y A VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 Y B VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 Y D VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 Y C VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A sndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B sndB VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 sndB C sndC VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 sndC D VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nand4_4 A B C D VGND VNB VPB VPWR Y
MMP0 Y A VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 Y B VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 Y D VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 Y C VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A sndA VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B sndB VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 sndB C sndC VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 sndC D VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nand4b_1 A_N B C D VGND VNB VPB VPWR Y
MMP0 Y A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 Y B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 Y C VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 Y D VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 A A_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A sndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B sndB VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 sndB C sndC VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 sndC D VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 A A_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nand4b_2 A_N B C D VGND VNB VPB VPWR Y
MMP0 Y A VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 Y B VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 Y C VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 Y D VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 A A_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A sndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B sndB VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 sndB C sndC VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 sndC D VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 A A_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nand4b_4 A_N B C D VGND VNB VPB VPWR Y
MMP0 Y A VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 Y B VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 Y C VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 Y D VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 A A_N VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A sndA VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B sndB VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 sndB C sndC VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 sndC D VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 A A_N VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nand4bb_1 A_N B_N C D VGND VNB VPB VPWR Y
MMP0 Y A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 Y B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 Y C VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 Y D VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 A A_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 B B_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A sndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B sndB VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 sndB C sndC VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 sndC D VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 A A_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 B B_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nand4bb_2 A_N B_N C D VGND VNB VPB VPWR Y
MMP0 Y A VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 Y B VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 Y C VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 Y D VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 A A_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 B B_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A sndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B sndB VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 sndB C sndC VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 sndC D VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 A A_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 B B_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nand4bb_4 A_N B_N C D VGND VNB VPB VPWR Y
MMP0 Y A VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 Y B VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 Y C VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 Y D VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 A A_N VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 B B_N VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A sndA VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B sndB VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 sndB C sndC VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 sndC D VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 A A_N VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 B B_N VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 Y B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nor2_2 A B VGND VNB VPB VPWR Y
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 Y B VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nor2_4 A B VGND VNB VPB VPWR Y
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 Y B VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nor2_8 A B VGND VNB VPB VPWR Y
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=8 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B Y VPB pfet_01v8_hvt m=8 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A VGND VNB nfet_01v8 m=8 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 Y B VGND VNB nfet_01v8 m=8 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nor2b_1 A B_N VGND VNB VPB VPWR Y
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 B B_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 Y B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 B B_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nor2b_2 A B_N VGND VNB VPB VPWR Y
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 B B_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 Y B VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 B B_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nor2b_4 A B_N VGND VNB VPB VPWR Y
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 B B_N VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 Y B VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 B B_N VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nor3_1 A B C VGND VNB VPB VPWR Y
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B sndPB VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 sndPB C Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 Y B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 Y C VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nor3_2 A B C VGND VNB VPB VPWR Y
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B sndPB VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 sndPB C Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 Y B VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 Y C VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nor3_4 A B C VGND VNB VPB VPWR Y
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B sndPB VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 sndPB C Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 Y B VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 Y C VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nor3b_1 A B C_N VGND VNB VPB VPWR Y
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B sndPB VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 sndPB C Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 C C_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 Y B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 Y C VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 C C_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nor3b_2 A B C_N VGND VNB VPB VPWR Y
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B sndPB VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 sndPB C Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 C C_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 Y B VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 Y C VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 C C_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nor3b_4 A B C_N VGND VNB VPB VPWR Y
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B sndPB VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 sndPB C Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 C C_N VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 Y B VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 Y C VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 C C_N VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nor4_1 A B C D VGND VNB VPB VPWR Y
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMP1 sndPA B sndPB VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMP2 sndPB C sndPC VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMP3 sndPC D Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMN0 Y A VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.028 perim=0.76
MMN1 Y B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.028 perim=0.76
MMN2 Y C VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.028 perim=0.76
MMN3 Y D VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.028 perim=0.76
.ENDS

.SUBCKT sky130_fd_sc_hd__nor4_2 A B C D VGND VNB VPB VPWR Y
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMP1 sndPA B sndPB VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMP2 sndPB C sndPC VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMP3 sndPC D Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMN0 Y A VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.028 perim=0.76
MMN1 Y B VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.028 perim=0.76
MMN2 Y C VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.028 perim=0.76
MMN3 Y D VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.028 perim=0.76
.ENDS

.SUBCKT sky130_fd_sc_hd__nor4_4 A B C D VGND VNB VPB VPWR Y
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMP1 sndPA B sndPB VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMP2 sndPB C sndPC VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMP3 sndPC D Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMN0 Y A VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.028 perim=0.76
MMN1 Y B VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.028 perim=0.76
MMN2 Y C VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.028 perim=0.76
MMN3 Y D VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.028 perim=0.76
.ENDS

.SUBCKT sky130_fd_sc_hd__nor4b_1 A B C D_N VGND VNB VPB VPWR Y
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B sndPB VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 sndPB C sndPC VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 sndPC D Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP3 D D_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 Y B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 Y C VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 Y D VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 D D_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nor4b_2 A B C D_N VGND VNB VPB VPWR Y
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B sndPB VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 sndPB C sndPC VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 sndPC D Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP3 D D_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 Y B VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 Y C VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 Y D VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 D D_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nor4b_4 A B C D_N VGND VNB VPB VPWR Y
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B sndPB VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 sndPB C sndPC VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 sndPC D Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP3 D D_N VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 Y B VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 Y C VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 Y D VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 D D_N VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nor4bb_1 A B C_N D_N VGND VNB VPB VPWR Y
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B sndPB VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 sndPB C sndPC VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 sndPC D Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 C C_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP3 D D_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 Y B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 Y C VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 Y D VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 C C_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 D D_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nor4bb_2 A B C_N D_N VGND VNB VPB VPWR Y
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B sndPB VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 sndPB C sndPC VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 sndPC D Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 C C_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP3 D D_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 Y B VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 Y C VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 Y D VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 C C_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 D D_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nor4bb_4 A B C_N D_N VGND VNB VPB VPWR Y
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B sndPB VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 sndPB C sndPC VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 sndPC D Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 C C_N VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP3 D D_N VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 Y B VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 Y C VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 Y D VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 C C_N VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 D D_N VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o2bb2a_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
MMIN2 X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNnand0 VGND A1_N sndNA1N VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNnand1 sndNA1N A2_N inand VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi10 nmid B1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi11 nmid B2 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi20 y inand nmid VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnand0 inand A1_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnand1 inand A2_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi10 VPWR B1 sndPB1 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi11 sndPB1 B2 y VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi20 y inand VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o2bb2a_2 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
MMIN2 X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNnand0 VGND A1_N sndNA1N VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNnand1 sndNA1N A2_N inand VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi10 nmid B1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi11 nmid B2 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi20 y inand nmid VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnand0 inand A1_N VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnand1 inand A2_N VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi10 VPWR B1 sndPB1 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi11 sndPB1 B2 y VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi20 y inand VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o2bb2a_4 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
MMIN2 X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNnand0 VGND A1_N sndNA1N VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNnand1 sndNA1N A2_N inand VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi10 nmid B1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi11 nmid B2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi20 y inand nmid VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnand0 inand A1_N VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnand1 inand A2_N VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi10 VPWR B1 sndPB1 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi11 sndPB1 B2 y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi20 y inand VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o2bb2ai_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR Y
MMNnand0 VGND A1_N sndNA1N VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNnand1 sndNA1N A2_N inand VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi10 nmid B1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi11 nmid B2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi20 Y inand nmid VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnand0 inand A1_N VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnand1 inand A2_N VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi10 VPWR B1 sndPB1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi11 sndPB1 B2 Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi20 Y inand VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o2bb2ai_2 A1_N A2_N B1 B2 VGND VNB VPB VPWR Y
MMNnand0 VGND A1_N sndNA1N VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNnand1 sndNA1N A2_N inand VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi10 nmid B1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi11 nmid B2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi20 Y inand nmid VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnand0 inand A1_N VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnand1 inand A2_N VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi10 VPWR B1 sndPB1 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi11 sndPB1 B2 Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi20 Y inand VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o2bb2ai_4 A1_N A2_N B1 B2 VGND VNB VPB VPWR Y
MMNnand0 VGND A1_N sndNA1N VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNnand1 sndNA1N A2_N inand VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi10 nmid B1 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi11 nmid B2 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi20 Y inand nmid VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnand0 inand A1_N VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnand1 inand A2_N VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi10 VPWR B1 sndPB1 VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi11 sndPB1 B2 Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi20 Y inand VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o21a_2 A1 A2 B1 VGND VNB VPB VPWR X
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o21a_4 A1 A2 B1 VGND VNB VPB VPWR X
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA20 VPWR A1 snd2A1 VPB pfet_01v8_hvt w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 y VPB pfet_01v8_hvt w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA21 snd2A1 A2 y VPB pfet_01v8_hvt w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 pndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o21ai_0 A1 A2 B1 VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 Y VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 Y VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 pndA VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 Y VPB pfet_01v8_hvt m=1 w=0.7 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o21ai_2 A1 A2 B1 VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 pndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o21ai_4 A1 A2 B1 VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 pndA VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o21ba_1 A1 A2 B1_N VGND VNB VPB VPWR X
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPB1N B1 B1_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINB1N B1 B1_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o21ba_2 A1 A2 B1_N VGND VNB VPB VPWR X
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPB1N B1 B1_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINB1N B1 B1_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o21ba_4 A1 A2 B1_N VGND VNB VPB VPWR X
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPB1N B1 B1_N VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 pndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINB1N B1 B1_N VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o21bai_1 A1 A2 B1_N VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPB1N B1 B1_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINB1N B1 B1_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o21bai_2 A1 A2 B1_N VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPB1N B1 B1_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 pndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINB1N B1 B1_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o21bai_4 A1 A2 B1_N VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPB1N B1 B1_N VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 pndA VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINB1N B1 B1_N VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o22a_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 sndB1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 sndB1 B2 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 y B2 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o22a_2 A1 A2 B1 B2 VGND VNB VPB VPWR X
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 sndB1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 sndB1 B2 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 y B2 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o22a_4 A1 A2 B1 B2 VGND VNB VPB VPWR X
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 sndB1 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 sndB1 B2 y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 pndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 y B2 pndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o22ai_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 sndB1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 sndB1 B2 Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 Y B2 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o22ai_2 A1 A2 B1 B2 VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 sndB1 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 sndB1 B2 Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 pndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 Y B2 pndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o22ai_4 A1 A2 B1 B2 VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 sndB1 VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 sndB1 B2 Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 pndA VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 Y B2 pndA VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o31a_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 sndA2 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 sndA2 A3 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 pndA A3 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o31a_2 A1 A2 A3 B1 VGND VNB VPB VPWR X
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 sndA2 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 sndA2 A3 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 pndA A3 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o31a_4 A1 A2 A3 B1 VGND VNB VPB VPWR X
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 sndA2 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 sndA2 A3 y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 pndA A3 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 pndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o31ai_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 sndA2 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 sndA2 A3 Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 pndA A3 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o31ai_2 A1 A2 A3 B1 VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 sndA2 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 sndA2 A3 Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 pndA A3 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 pndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o31ai_4 A1 A2 A3 B1 VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 sndA2 VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 sndA2 A3 Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 pndA A3 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 pndA VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o32a_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 sndA2 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 sndA2 A3 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 sndB1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 sndB1 B2 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 pndA A3 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 y B2 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o32a_2 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 sndA2 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 sndA2 A3 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 sndB1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 sndB1 B2 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 pndA A3 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 y B2 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o32a_4 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 sndA2 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 sndA2 A3 y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 sndB1 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 sndB1 B2 y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 pndA A3 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 pndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 y B2 pndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o32ai_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 sndA2 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 sndA2 A3 Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 sndB1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 sndB1 B2 Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 pndA A3 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 Y B2 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o32ai_2 A1 A2 A3 B1 B2 VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 sndA2 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 sndA2 A3 Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 sndB1 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 sndB1 B2 Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 pndA A3 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 pndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 Y B2 pndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o32ai_4 A1 A2 A3 B1 B2 VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 sndA2 VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 sndA2 A3 Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 sndB1 VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 sndB1 B2 Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 pndA A3 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 pndA VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 Y B2 pndA VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o41a_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 sndA2 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 sndA2 A3 sndA3 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA3 sndA3 A4 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 pndA A3 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA3 pndA A4 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o41a_2 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 sndA2 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 sndA2 A3 sndA3 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA3 sndA3 A4 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 pndA A3 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA3 pndA A4 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o41a_4 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 sndA2 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 sndA2 A3 sndA3 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA3 sndA3 A4 y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 pndA A3 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA3 pndA A4 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 pndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o41ai_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 sndA2 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 sndA2 A3 sndA3 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA3 sndA3 A4 Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 pndA A3 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA3 pndA A4 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o41ai_2 A1 A2 A3 A4 B1 VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 sndA2 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 sndA2 A3 sndA3 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA3 sndA3 A4 Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 pndA A3 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA3 pndA A4 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 pndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o41ai_4 A1 A2 A3 A4 B1 VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 sndA2 VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 sndA2 A3 sndA3 VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA3 sndA3 A4 Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 pndA A3 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA3 pndA A4 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 pndA VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o211a_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 VPWR C1 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 pndB B1 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 y C1 pndB VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o211a_2 A1 A2 B1 C1 VGND VNB VPB VPWR X
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 VPWR C1 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 pndB B1 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 y C1 pndB VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o211a_4 A1 A2 B1 C1 VGND VNB VPB VPWR X
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 VPWR C1 y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 pndB B1 pndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 y C1 pndB VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o211ai_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 VPWR C1 Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 pndB B1 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 Y C1 pndB VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o211ai_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 VPWR C1 Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 pndB B1 pndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 Y C1 pndB VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o211ai_4 A1 A2 B1 C1 VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 VPWR C1 Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 pndB B1 pndA VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 Y C1 pndB VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o221a_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 sndB1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 sndB1 B2 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 VPWR C1 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 pndB B1 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 pndB B2 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 y C1 pndB VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o221a_2 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 sndB1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 sndB1 B2 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 VPWR C1 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 pndB B1 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 pndB B2 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 y C1 pndB VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o221a_4 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 sndB1 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 sndB1 B2 y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 VPWR C1 y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 pndB B1 pndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 pndB B2 pndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 y C1 pndB VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o221ai_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 sndB1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 sndB1 B2 Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 VPWR C1 Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 pndB B1 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 pndB B2 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 Y C1 pndB VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o221ai_2 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 sndB1 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 sndB1 B2 Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 VPWR C1 Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 pndB B1 pndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 pndB B2 pndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 Y C1 pndB VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o221ai_4 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 sndB1 VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 sndB1 B2 Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 VPWR C1 Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 pndB B1 pndA VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 pndB B2 pndA VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 Y C1 pndB VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o311a_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 sndA2 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 sndA2 A3 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 VPWR C1 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 pndA A3 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 pndB B1 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 y C1 pndB VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o311a_2 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 sndA2 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 sndA2 A3 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 VPWR C1 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 pndA A3 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 pndB B1 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 y C1 pndB VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o311a_4 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 sndA2 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 sndA2 A3 y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 VPWR C1 y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 pndA A3 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 pndB B1 pndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 y C1 pndB VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o311ai_0 A1 A2 A3 B1 C1 VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 sndA2 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 sndA2 A3 Y VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 Y VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 VPWR C1 Y VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 pndA A3 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 pndB B1 pndA VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 Y C1 pndB VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o311ai_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 sndA2 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 sndA2 A3 Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 VPWR C1 Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 pndA A3 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 pndB B1 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 Y C1 pndB VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o311ai_2 A1 A2 A3 B1 C1 VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 sndA2 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 sndA2 A3 Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 VPWR C1 Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 pndA A3 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 pndB B1 pndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 Y C1 pndB VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o311ai_4 A1 A2 A3 B1 C1 VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 sndA2 VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 sndA2 A3 Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 VPWR C1 Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 pndA A3 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 pndB B1 pndA VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 Y C1 pndB VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o2111a_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 VPWR C1 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPD0 VPWR D1 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 pndB B1 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 pndC C1 pndB VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMND0 y D1 pndC VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o2111a_2 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 VPWR C1 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPD0 VPWR D1 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 pndB B1 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 pndC C1 pndB VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMND0 y D1 pndC VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o2111a_4 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 VPWR C1 y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPD0 VPWR D1 y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 pndB B1 pndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 pndC C1 pndB VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMND0 y D1 pndC VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o2111ai_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 VPWR C1 Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPD0 VPWR D1 Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 pndB B1 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 pndC C1 pndB VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMND0 Y D1 pndC VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o2111ai_2 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 VPWR C1 Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPD0 VPWR D1 Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 pndB B1 pndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 pndC C1 pndB VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMND0 Y D1 pndC VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o2111ai_4 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 VPWR C1 Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPD0 VPWR D1 Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 pndB B1 pndA VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 pndC C1 pndB VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMND0 Y D1 pndC VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__or2_0 A B VGND VNB VPB VPWR X
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B y VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X y VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 y B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 X y VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B y VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 y B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__or2_2 A B VGND VNB VPB VPWR X
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B y VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 y B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__or2_4 A B VGND VNB VPB VPWR X
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 y B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__or2b_1 A B_N VGND VNB VPB VPWR X
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B y VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 B B_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 y B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 B B_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__or2b_2 A B_N VGND VNB VPB VPWR X
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B y VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 B B_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 y B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 B B_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__or2b_4 A B_N VGND VNB VPB VPWR X
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 B B_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 y B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 B B_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__or3_1 A B C VGND VNB VPB VPWR X
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B sndPB VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 sndPB C y VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP3 X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 y B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 y C VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__or3_2 A B C VGND VNB VPB VPWR X
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B sndPB VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 sndPB C y VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP3 X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 y B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 y C VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__or3_4 A B C VGND VNB VPB VPWR X
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B sndPB VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 sndPB C y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP3 X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 y B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 y C VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__or3b_1 A B C_N VGND VNB VPB VPWR X
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B sndPB VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 sndPB C y VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 C C_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP3 X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 y B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 y C VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 C C_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__or3b_2 A B C_N VGND VNB VPB VPWR X
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B sndPB VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 sndPB C y VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 C C_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP3 X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 y B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 y C VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 C C_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__or3b_4 A B C_N VGND VNB VPB VPWR X
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B sndPB VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 sndPB C y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 C C_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP3 X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 y B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 y C VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 C C_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__or4_1 A B C D VGND VNB VPB VPWR X
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B sndPB VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 sndPB C sndPC VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 sndPC D y VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP4 X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 y B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 y C VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 y D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN4 X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__or4_2 A B C D VGND VNB VPB VPWR X
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B sndPB VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 sndPB C sndPC VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 sndPC D y VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP4 X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 y B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 y C VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 y D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN4 X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__or4_4 A B C D VGND VNB VPB VPWR X
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B sndPB VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 sndPB C sndPC VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 sndPC D y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP4 X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 y B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 y C VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 y D VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN4 X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__or4b_1 A B C D_N VGND VNB VPB VPWR X
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B sndPB VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 sndPB C sndPC VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 sndPC D y VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP3 D D_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP4 X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 y B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 y C VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 y D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 D D_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN4 X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__or4b_2 A B C D_N VGND VNB VPB VPWR X
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B sndPB VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 sndPB C sndPC VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 sndPC D y VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP3 D D_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP4 X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 y B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 y C VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 y D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 D D_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN4 X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__or4b_4 A B C D_N VGND VNB VPB VPWR X
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B sndPB VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 sndPB C sndPC VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 sndPC D y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP3 D D_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP4 X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 y B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 y C VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 y D VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 D D_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN4 X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__or4bb_1 A B C_N D_N VGND VNB VPB VPWR X
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B sndPB VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 sndPB C sndPC VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 sndPC D y VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 C C_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP3 D D_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP4 X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 y B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 y C VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 y D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 C C_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 D D_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN4 X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__or4bb_2 A B C_N D_N VGND VNB VPB VPWR X
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B sndPB VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 sndPB C sndPC VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 sndPC D y VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 C C_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP3 D D_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP4 X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 y B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 y C VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 y D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 C C_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 D D_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN4 X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__or4bb_4 A B C_N D_N VGND VNB VPB VPWR X
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B sndPB VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 sndPB C sndPC VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 sndPC D y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 C C_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP3 D D_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP4 X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 y B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 y C VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 y D VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 C C_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 D D_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN4 X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__probe_p_8 A VGND VNB VPB VPWR X
MMIP1 Ab A VPWR VPB pfet_01v8_hvt m=3 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 net29 Ab VPWR VPB pfet_01v8_hvt m=8 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 Ab A VGND VNB nfet_01v8 m=3 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 net29 Ab VGND VNB nfet_01v8 m=8 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
rI112 net29 X short
.ENDS

.SUBCKT sky130_fd_sc_hd__probec_p_8 A VGND VNB VPB VPWR X
MMIP1 Ab A VPWR VPB pfet_01v8_hvt m=3 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 net33 Ab VPWR VPB pfet_01v8_hvt m=8 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 Ab A VGND VNB nfet_01v8 m=3 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 net33 Ab VGND VNB nfet_01v8 m=8 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
rI112 net33 X short
rI120 VGND met5vgnd short
rI119 VPWR met5vpwr short
.ENDS

.SUBCKT sky130_fd_sc_hd__sdfbbn_1 CLK_N D RESET_B SCD SCE SET_B VGND VNB VPB VPWR Q Q_N
MI98 net105 D n0 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI103 n1 SCD VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI104 n0 sceb VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI120 net105 SCE n1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI46 clkneg clkpos VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI642 RESET RESET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI676 M1 M0 net176 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI675 net176 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 Q net213 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI677 M1 RESET net176 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 M0 clkpos net153 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 clkpos CLK_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 net153 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 S0 clkneg net145 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net145 net117 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 Q_N net117 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 net213 net117 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 net105 clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI668 S0 clkpos net125 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI667 net125 M1 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI630 net117 RESET net116 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI3 net117 S0 net116 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI7 net116 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI639 sceb SCE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI107 p0 SCE VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI94 net105 D p0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI101 net105 sceb p1 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI108 p1 SCD VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI679 M1 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI669 S0 clkneg net265 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI660 Q net213 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI9 net117 S0 net268 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI670 net265 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI678 net216 RESET VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI662 net257 net117 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 S0 clkpos net257 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI10 net117 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI11 net268 RESET VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 net241 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 net105 clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 M0 clkneg net241 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI643 RESET RESET_B VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 clkneg clkpos VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 clkpos CLK_N VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI680 M1 M0 net216 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI663 net213 net117 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI661 Q_N net117 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI640 sceb SCE VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__sdfbbn_2 CLK_N D RESET_B SCD SCE SET_B VGND VNB VPB VPWR Q Q_N
MI98 net105 D n0 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI103 n1 SCD VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI104 n0 sceb VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI120 net105 SCE n1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI46 clkneg clkpos VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI642 RESET RESET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI676 M1 M0 net176 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI675 net176 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 Q net213 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI677 M1 RESET net176 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 M0 clkpos net160 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 clkpos CLK_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 net160 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 S0 clkneg net145 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net145 net117 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 Q_N net117 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 net213 net117 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 net105 clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI668 S0 clkpos net128 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI667 net128 M1 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI630 net117 RESET net116 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI3 net117 S0 net116 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI7 net116 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI639 sceb SCE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI107 p0 SCE VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI94 net105 D p0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI101 net105 sceb p1 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI108 p1 SCD VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI679 M1 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI669 S0 clkneg net265 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI660 Q net213 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI9 net117 S0 net268 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI670 net265 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI678 net216 RESET VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI662 net257 net117 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 S0 clkpos net257 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI10 net117 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI11 net268 RESET VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 net241 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 net105 clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 M0 clkneg net241 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI643 RESET RESET_B VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 clkneg clkpos VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 clkpos CLK_N VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI680 M1 M0 net216 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI663 net213 net117 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI661 Q_N net117 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI640 sceb SCE VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__sdfbbp_1 CLK D RESET_B SCD SCE SET_B VGND VNB VPB VPWR Q Q_N
MI98 net105 D n0 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI103 n1 SCD VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI104 n0 sceb VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI120 net105 SCE n1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI46 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI642 RESET RESET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI676 M1 M0 net176 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI675 net176 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 Q net213 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI677 M1 RESET net176 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 M0 clkpos net160 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 net160 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 S0 clkneg net145 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net145 net117 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 Q_N net117 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 net213 net117 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 net105 clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI668 S0 clkpos net125 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI667 net125 M1 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI630 net117 RESET net116 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI3 net117 S0 net116 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI7 net116 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI639 sceb SCE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI107 p0 SCE VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI94 net105 D p0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI101 net105 sceb p1 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI108 p1 SCD VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI679 M1 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI669 S0 clkneg net265 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI660 Q net213 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI9 net117 S0 net268 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI670 net265 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI678 net216 RESET VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI662 net257 net117 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 S0 clkpos net257 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI10 net117 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI11 net268 RESET VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 net241 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 net105 clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 M0 clkneg net241 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI643 RESET RESET_B VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI680 M1 M0 net216 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI663 net213 net117 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI661 Q_N net117 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI640 sceb SCE VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__sdfrbp_1 CLK D RESET_B SCD SCE VGND VNB VPB VPWR Q Q_N
MI642 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net92 S0 net134 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net134 RESET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI33 net127 RESET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 sceb SCE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI4 M0 clkpos net115 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 net115 M1 net127 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 S0 clkneg net103 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 Q net92 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net103 net92 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI647 M1 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 M1 clkpos S0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI672 net171 net92 VGND VNB nfet_01v8 m=1 w=0.52 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI670 Q_N net171 VGND VNB nfet_01v8 m=1 w=0.52 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI98 db D n0 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.525 perim=3.1
MI103 n1 SCD VGND VNB nfet_01v8 m=1 w=0.42 l=0.18 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI120 db SCE n1 VNB nfet_01v8 m=1 w=0.42 l=0.5 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI104 n0 sceb VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI643 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI635 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI662 net215 net92 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 net92 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 S0 clkpos net215 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net92 S0 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI30 net194 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI31 M0 clkneg net194 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI32 net194 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI663 Q net92 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 M1 clkneg S0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI633 sceb SCE VPWR VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI673 net171 net92 VPWR VPB pfet_01v8_hvt m=1 w=0.79 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI671 Q_N net171 VPWR VPB pfet_01v8_hvt m=1 w=0.79 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI101 db sceb p1 VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI107 p0 SCE VPWR VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI94 db D p0 VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI108 p1 SCD VPWR VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__sdfrbp_2 CLK D RESET_B SCD SCE VGND VNB VPB VPWR Q Q_N
MI642 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net92 S0 net134 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net134 RESET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI33 net127 RESET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 sceb SCE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI4 M0 clkpos net115 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 net115 M1 net127 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 S0 clkneg net110 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 Q net92 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net110 net92 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI647 M1 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 M1 clkpos S0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI672 net171 net92 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI670 Q_N net171 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI98 db D n0 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.525 perim=3.1
MI103 n1 SCD VGND VNB nfet_01v8 m=1 w=0.42 l=0.18 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI120 db SCE n1 VNB nfet_01v8 m=1 w=0.42 l=0.5 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI104 n0 sceb VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI643 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI635 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI662 net215 net92 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 net92 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 S0 clkpos net215 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net92 S0 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI30 net194 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI31 M0 clkneg net194 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI32 net194 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI663 Q net92 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 M1 clkneg S0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI633 sceb SCE VPWR VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI673 net171 net92 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI671 Q_N net171 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI101 db sceb p1 VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI107 p0 SCE VPWR VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI94 db D p0 VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI108 p1 SCD VPWR VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__sdfrtn_1 CLK_N D RESET_B SCD SCE VGND VNB VPB VPWR Q
MI642 clkpos CLK_N VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkneg clkpos VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net87 net153 net117 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net117 RESET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI33 net110 RESET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 sceb SCE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI4 M0 clkpos net98 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 net98 M1 net110 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 net153 clkneg net93 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 Q net87 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net93 net87 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI647 M1 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 M1 clkpos net153 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI98 db D n0 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.525 perim=3.1
MI103 n1 SCD VGND VNB nfet_01v8 m=1 w=0.42 l=0.18 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI120 db SCE n1 VNB nfet_01v8 m=1 w=0.42 l=0.5 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI104 n0 sceb VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI643 clkpos CLK_N VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI635 clkneg clkpos VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI662 net190 net87 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 net87 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 net153 clkpos net190 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net87 net153 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI30 net169 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI31 M0 clkneg net169 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI32 net169 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI660 Q net87 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 M1 clkneg net153 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI633 sceb SCE VPWR VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI101 db sceb p1 VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI107 p0 SCE VPWR VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI94 db D p0 VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI108 p1 SCD VPWR VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__sdfrtp_1 CLK D RESET_B SCD SCE VGND VNB VPB VPWR Q
MI642 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net84 S0 net114 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net114 RESET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI33 net107 RESET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 sceb SCE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI4 M0 clkpos net95 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 net95 M1 net107 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 S0 clkneg net83 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 Q net84 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net83 net84 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI647 M1 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 M1 clkpos S0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI98 db D n0 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.525 perim=3.1
MI103 n1 SCD VGND VNB nfet_01v8 m=1 w=0.42 l=0.18 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI120 db SCE n1 VNB nfet_01v8 m=1 w=0.42 l=0.5 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI104 n0 sceb VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI643 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI635 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI662 net187 net84 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 net84 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 S0 clkpos net187 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net84 S0 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI30 net166 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI31 M0 clkneg net166 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI32 net166 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI663 Q net84 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 M1 clkneg S0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI633 sceb SCE VPWR VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI101 db sceb p1 VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI107 p0 SCE VPWR VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI94 db D p0 VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI108 p1 SCD VPWR VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__sdfrtp_2 CLK D RESET_B SCD SCE VGND VNB VPB VPWR Q
MI642 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net84 S0 net114 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net114 RESET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI33 net107 RESET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 sceb SCE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI4 M0 clkpos net95 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 net95 M1 net107 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 S0 clkneg net90 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 Q net84 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net90 net84 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI647 M1 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 M1 clkpos S0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI98 db D n0 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.525 perim=3.1
MI103 n1 SCD VGND VNB nfet_01v8 m=1 w=0.42 l=0.18 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI120 db SCE n1 VNB nfet_01v8 m=1 w=0.42 l=0.5 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI104 n0 sceb VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI643 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI635 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI662 net187 net84 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 net84 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 S0 clkpos net187 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net84 S0 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI30 net166 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI31 M0 clkneg net166 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI32 net166 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI663 Q net84 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 M1 clkneg S0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI633 sceb SCE VPWR VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI101 db sceb p1 VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI107 p0 SCE VPWR VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI94 db D p0 VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI108 p1 SCD VPWR VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__sdfrtp_4 CLK D RESET_B SCD SCE VGND VNB VPB VPWR Q
MI642 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net84 S0 net114 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net114 RESET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI33 net107 RESET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 sceb SCE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI4 M0 clkpos net95 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 net95 M1 net107 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 S0 clkneg net90 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 Q net84 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net90 net84 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI647 M1 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 M1 clkpos S0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI98 db D n0 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.525 perim=3.1
MI103 n1 SCD VGND VNB nfet_01v8 m=1 w=0.42 l=0.18 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI120 db SCE n1 VNB nfet_01v8 m=1 w=0.42 l=0.5 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI104 n0 sceb VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI643 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI635 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI662 net187 net84 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 net84 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 S0 clkpos net187 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net84 S0 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI30 net166 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI31 M0 clkneg net166 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI32 net166 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI663 Q net84 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 M1 clkneg S0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI633 sceb SCE VPWR VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI101 db sceb p1 VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI107 p0 SCE VPWR VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI94 db D p0 VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI108 p1 SCD VPWR VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__sdfsbp_1 CLK D SCD SCE SET_B VGND VNB VPB VPWR Q Q_N
MI107 p0 SCE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI94 db D p0 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI101 db sceb p1 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI108 p1 SCD VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI662 net159 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 M0 clkneg net159 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 net138 S1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI669 S0 clkpos net138 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI661 Q_N S0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 M1 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI645 sceb SCE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI663 net199 S0 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI660 Q net199 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI24 S0 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 S1 S0 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI38 S0 clkneg net98 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI37 net98 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI120 db SCE n1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI104 n0 sceb VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI103 n1 SCD VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI98 db D n0 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.525 perim=3.1
MI27 net243 S1 net215 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI647 S1 S0 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI46 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 S0 clkpos net230 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net227 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 Q net199 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI644 sceb SCE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI25 net215 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 Q_N S0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 M0 clkpos net206 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 net199 S0 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 M1 M0 net227 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net206 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI36 net230 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI26 S0 clkneg net243 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 db clkneg M0 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__sdfsbp_2 CLK D SCD SCE SET_B VGND VNB VPB VPWR Q Q_N
MI101 db sceb p1 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI107 p0 SCE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI94 db D p0 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI108 p1 SCD VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI645 sceb SCE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI663 net195 S0 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI660 Q net195 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 M1 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI662 net130 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 M0 clkneg net130 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 net122 S1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI669 S0 clkpos net122 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI24 S0 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 S1 S0 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI38 S0 clkneg net107 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI37 net107 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI661 Q_N S0 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI98 db D n0 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.525 perim=3.1
MI103 n1 SCD VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI120 db SCE n1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI104 n0 sceb VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI34 S0 clkpos net219 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI27 net239 S1 net187 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI647 S1 S0 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 M0 clkpos net230 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 M1 M0 net199 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net230 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI36 net219 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI26 S0 clkneg net239 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 db clkneg M0 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI46 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net199 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 net195 S0 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI644 sceb SCE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI25 net187 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 Q net195 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 Q_N S0 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__sdfstp_1 CLK D SCD SCE SET_B VGND VNB VPB VPWR Q
MI645 sceb SCE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI663 net165 S0 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI660 Q net165 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 M1 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI662 net109 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 M0 clkneg net109 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 net96 S1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI669 S0 clkpos net96 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI24 S0 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 S1 S0 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI38 S0 clkneg net84 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI37 net84 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI101 db sceb p1 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI107 p0 SCE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI94 db D p0 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI108 p1 SCD VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 S0 clkpos net189 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI27 net209 S1 net157 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI647 S1 S0 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 M0 clkpos net200 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 M1 M0 net169 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net200 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI36 net189 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI26 S0 clkneg net209 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 db clkneg M0 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI46 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net169 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 net165 S0 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI644 sceb SCE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI25 net157 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 Q net165 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI98 db D n0 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.525 perim=3.1
MI103 n1 SCD VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI120 db SCE n1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI104 n0 sceb VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
.ENDS

.SUBCKT sky130_fd_sc_hd__sdfstp_2 CLK D SCD SCE SET_B VGND VNB VPB VPWR Q
MI645 sceb SCE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI663 net165 S0 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI660 Q net165 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 M1 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI662 net109 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 M0 clkneg net109 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 net96 S1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI669 S0 clkpos net96 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI24 S0 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 S1 S0 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI38 S0 clkneg net84 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI37 net84 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI101 db sceb p1 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI107 p0 SCE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI94 db D p0 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI108 p1 SCD VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 S0 clkpos net212 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI27 net209 S1 net157 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI647 S1 S0 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 M0 clkpos net200 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 M1 M0 net196 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net200 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI36 net212 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI26 S0 clkneg net209 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 db clkneg M0 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI46 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net196 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 net165 S0 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI644 sceb SCE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI25 net157 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 Q net165 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI98 db D n0 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.525 perim=3.1
MI103 n1 SCD VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI120 db SCE n1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI104 n0 sceb VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
.ENDS

.SUBCKT sky130_fd_sc_hd__sdfstp_4 CLK D SCD SCE SET_B VGND VNB VPB VPWR Q
MI645 sceb SCE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI663 net165 S0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI660 Q net165 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 M1 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI662 net104 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 M0 clkneg net104 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 net96 S1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI669 S0 clkpos net96 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI24 S0 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 S1 S0 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI38 S0 clkneg net84 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI37 net84 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI101 db sceb p1 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI107 p0 SCE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI94 db D p0 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI108 p1 SCD VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 S0 clkpos net189 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI27 net209 S1 net157 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI647 S1 S0 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 M0 clkpos net200 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 M1 M0 net169 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net200 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI36 net189 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI26 S0 clkneg net209 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 db clkneg M0 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI46 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net169 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 net165 S0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI644 sceb SCE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI25 net157 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 Q net165 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI98 db D n0 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.525 perim=3.1
MI103 n1 SCD VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI120 db SCE n1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI104 n0 sceb VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
.ENDS

.SUBCKT sky130_fd_sc_hd__sdfxbp_1 CLK D SCD SCE VGND VNB VPB VPWR Q Q_N
MI98 db D n0 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.525 perim=3.1
MI103 n1 SCD VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI120 db SCE n1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI104 n0 sceb VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI657 M0 clkpos net129 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net129 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI641 net120 S1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI642 S0 clkneg net120 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI646 Q S1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI635 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI639 sceb SCE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 M1 clkpos S0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI661 Q_N net153 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI662 net153 S1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 S1 S0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 M1 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI107 p0 SCE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI94 db D p0 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI101 db sceb p1 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI108 p1 SCD VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 S1 S0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI644 S0 clkpos net177 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.75 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net160 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI645 Q S1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI660 Q_N net153 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI643 net177 S1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 M1 clkneg S0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI640 sceb SCE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 M0 clkneg net160 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI647 net153 S1 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__sdfxbp_2 CLK D SCD SCE VGND VNB VPB VPWR Q Q_N
MI98 db D n0 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.525 perim=3.1
MI103 n1 SCD VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI120 db SCE n1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI104 n0 sceb VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI657 M0 clkpos net129 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net129 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI641 net120 S1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI642 S0 clkneg net120 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI646 Q S1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI635 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI639 sceb SCE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 M1 clkpos S0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI661 Q_N net153 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI662 net153 S1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 S1 S0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 M1 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI107 p0 SCE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI94 db D p0 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI101 db sceb p1 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI108 p1 SCD VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 S1 S0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI644 S0 clkpos net196 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.75 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net189 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI645 Q S1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI660 Q_N net153 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI643 net196 S1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 M1 clkneg S0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI640 sceb SCE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 M0 clkneg net189 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI647 net153 S1 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__sdfxtp_1 CLK D SCD SCE VGND VNB VPB VPWR Q
MI652 M1 clkpos S0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 S1 S0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 M1 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI639 sceb SCE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 M0 clkpos net78 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net78 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI641 net54 S1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI646 Q S1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI635 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI642 S0 clkneg net54 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI98 db D n0 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.525 perim=3.1
MI103 n1 SCD VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI120 db SCE n1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI104 n0 sceb VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI643 net122 S1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI640 sceb SCE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net155 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI645 Q S1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 M1 clkneg S0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 M0 clkneg net155 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 S1 S0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI644 S0 clkpos net122 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.75 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI107 p0 SCE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI94 db D p0 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI108 p1 SCD VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI101 db sceb p1 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__sdfxtp_2 CLK D SCD SCE VGND VNB VPB VPWR Q
MI652 M1 clkpos S0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 S1 S0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 M1 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI639 sceb SCE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 M0 clkpos net78 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net78 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI641 net54 S1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI646 Q S1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI635 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI642 S0 clkneg net54 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI98 db D n0 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.525 perim=3.1
MI103 n1 SCD VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI120 db SCE n1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI104 n0 sceb VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI643 net163 S1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI640 sceb SCE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net138 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI645 Q S1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 M1 clkneg S0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 M0 clkneg net138 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 S1 S0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI644 S0 clkpos net163 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.75 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI107 p0 SCE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI94 db D p0 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI108 p1 SCD VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI101 db sceb p1 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__sdfxtp_4 CLK D SCD SCE VGND VNB VPB VPWR Q
MI652 M1 clkpos S0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 S1 S0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 M1 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI639 sceb SCE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 M0 clkpos net78 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net78 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI641 net54 S1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI646 Q S1 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI635 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI642 S0 clkneg net54 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI98 db D n0 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.525 perim=3.1
MI103 n1 SCD VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI120 db SCE n1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI104 n0 sceb VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI643 net163 S1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI640 sceb SCE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net155 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI645 Q S1 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 M1 clkneg S0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 M0 clkneg net155 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 S1 S0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI644 S0 clkpos net163 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.75 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI107 p0 SCE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI94 db D p0 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI108 p1 SCD VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI101 db sceb p1 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__sdlclkp_1 CLK GATE SCE VGND VNB VPB VPWR GCLK
MI662 net88 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 M0 clkpos net88 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 net76 CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net76 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 m1 M0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI22 net63 SCE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI21 net116 GATE net63 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 clkneg clkpos VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 clkpos CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI660 GCLK net76 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 net116 clkneg M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 net116 clkpos M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI20 m1 M0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 M0 clkneg net123 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net123 m1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI24 net116 SCE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net112 CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net76 m1 net112 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI23 net116 GATE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI46 clkneg clkpos VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 clkpos CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 GCLK net76 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__sdlclkp_2 CLK GATE SCE VGND VNB VPB VPWR GCLK
MI662 net88 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 M0 clkpos net88 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 net76 CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net76 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 m1 M0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI22 net63 SCE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI21 net116 GATE net63 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 clkneg clkpos VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 clkpos CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI660 GCLK net76 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 net116 clkneg M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 net116 clkpos M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI20 m1 M0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 M0 clkneg net123 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net123 m1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI24 net116 SCE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net112 CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net76 m1 net112 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI23 net116 GATE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI46 clkneg clkpos VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 clkpos CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 GCLK net76 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__sdlclkp_4 CLK GATE SCE VGND VNB VPB VPWR GCLK
MI662 net88 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 M0 clkpos net88 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 net76 CLK VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net76 m1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 m1 M0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI22 net63 SCE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI21 net116 GATE net63 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 clkneg clkpos VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 clkpos CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI660 GCLK net76 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 net116 clkneg M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 net116 clkpos M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI20 m1 M0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 M0 clkneg net123 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net123 m1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI24 net116 SCE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net112 CLK VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net76 m1 net112 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI23 net116 GATE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI46 clkneg clkpos VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 clkpos CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 GCLK net76 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__sedfxbp_1 CLK D DE SCD SCE VGND VNB VPB VPWR Q Q_N
MI14 net155 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI13 S0 clkneg net155 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI645 Q S0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net123 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI643 net127 q1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI639 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.75 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI644 S0 clkpos net127 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 M0 clkneg net123 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 q1 S0 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI33 net116 deneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 net107 sceneg db VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI46 VPWR SCD net107 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI31 net104 D net116 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 net104 SCE db VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI40 net87 q1 net104 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI36 deneg DE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI38 VPWR DE net87 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 sceneg SCE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI52 Q_N q1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 M1 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI635 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI641 net235 q1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI642 S0 clkneg net235 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI646 Q S0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net224 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 M0 clkpos net224 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 net104 sceneg db VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI18 q1 S0 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 sceneg SCE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI32 net104 D net203 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI16 net200 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI15 S0 clkpos net200 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI41 net192 q1 net104 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI39 VGND deneg net192 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI37 deneg DE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 net203 DE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI49 net176 SCE db VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI48 VGND SCD net176 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI53 Q_N q1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__sedfxbp_2 CLK D DE SCD SCE VGND VNB VPB VPWR Q Q_N
MI14 net155 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI13 S0 clkneg net155 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI645 Q S0 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net144 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI643 net127 q1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI639 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.75 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI644 S0 clkpos net127 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 M0 clkneg net144 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 q1 S0 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI33 net116 deneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 net107 sceneg db VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI46 VPWR SCD net107 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI31 net104 D net116 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 net104 SCE db VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI40 net87 q1 net104 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI36 deneg DE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI38 VPWR DE net87 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 sceneg SCE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI52 Q_N q1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 M1 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI635 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI641 net240 q1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI642 S0 clkneg net240 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI646 Q S0 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net224 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 M0 clkpos net224 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 net104 sceneg db VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI18 q1 S0 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 sceneg SCE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI32 net104 D net180 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI16 net200 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI15 S0 clkpos net200 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI41 net192 q1 net104 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI39 VGND deneg net192 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI37 deneg DE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 net180 DE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI49 net176 SCE db VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI48 VGND SCD net176 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI53 Q_N q1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__sedfxtp_1 CLK D DE SCD SCE VGND VNB VPB VPWR Q
MI14 net146 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI13 S0 clkneg net146 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI645 Q S0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net114 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI643 net118 q1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI639 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.75 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI644 S0 clkpos net118 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 M0 clkneg net114 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 q1 S0 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI33 net94 deneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 net103 sceneg db VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI46 VPWR SCD net103 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI31 net95 D net94 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 net95 SCE db VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI40 net87 q1 net95 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI36 deneg DE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI38 VPWR DE net87 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 sceneg SCE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 M1 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI635 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI641 net222 q1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI642 S0 clkneg net222 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI646 Q S0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net211 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 M0 clkpos net211 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 net95 sceneg db VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI18 q1 S0 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 sceneg SCE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI32 net95 D net167 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI16 net187 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI15 S0 clkpos net187 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI41 net179 q1 net95 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI39 VGND deneg net179 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI37 deneg DE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 net167 DE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI49 net158 SCE db VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI48 VGND SCD net158 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__sedfxtp_2 CLK D DE SCD SCE VGND VNB VPB VPWR Q
MI14 net146 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI13 S0 clkneg net146 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI645 Q S0 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net114 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI643 net118 q1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI639 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.75 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI644 S0 clkpos net118 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 M0 clkneg net114 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 q1 S0 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI33 net94 deneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 net98 sceneg db VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI46 VPWR SCD net98 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI31 net95 D net94 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 net95 SCE db VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI40 net87 q1 net95 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI36 deneg DE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI38 VPWR DE net87 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 sceneg SCE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 M1 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI635 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI641 net222 q1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI642 S0 clkneg net222 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI646 Q S0 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net211 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 M0 clkpos net211 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 net95 sceneg db VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI18 q1 S0 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 sceneg SCE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI32 net95 D net167 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI16 net187 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI15 S0 clkpos net187 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI41 net174 q1 net95 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI39 VGND deneg net174 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI37 deneg DE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 net167 DE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI49 net158 SCE db VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI48 VGND SCD net158 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__sedfxtp_4 CLK D DE SCD SCE VGND VNB VPB VPWR Q
MI14 net146 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI13 S0 clkneg net146 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI645 Q S0 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net135 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI643 net118 q1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI639 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.75 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI644 S0 clkpos net118 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 M0 clkneg net135 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 q1 S0 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI33 net107 deneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 net98 sceneg db VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI46 VPWR SCD net98 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI31 net95 D net107 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 net95 SCE db VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI40 net87 q1 net95 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI36 deneg DE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI38 VPWR DE net87 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 sceneg SCE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 M1 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI635 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI641 net227 q1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI642 S0 clkneg net227 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI646 Q S0 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net206 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 M0 clkpos net206 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 net95 sceneg db VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI18 q1 S0 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 sceneg SCE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI32 net95 D net190 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI16 net187 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI15 S0 clkpos net187 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI41 net174 q1 net95 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI39 VGND deneg net174 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI37 deneg DE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 net190 DE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI49 net163 SCE db VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI48 VGND SCD net163 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__tap_1 VGND VNB VPB VPWR
.ENDS

.SUBCKT sky130_fd_sc_hd__tap_2 VGND VNB VPB VPWR
.ENDS

.SUBCKT sky130_fd_sc_hd__tapvgnd2_1 VGND VPB VPWR
.ENDS

.SUBCKT sky130_fd_sc_hd__tapvgnd_1 VGND VPB VPWR
.ENDS

.SUBCKT sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ENDS

.SUBCKT sky130_fd_sc_hd__xnor2_1 A B VGND VNB VPB VPWR Y
MMNnand0 VGND A sndNA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNnand1 sndNA B inand VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi10 nmid A VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi11 nmid B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi20 Y inand nmid VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnand0 inand A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnand1 inand B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi10 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi11 sndPA B Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi20 Y inand VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__xnor2_2 A B VGND VNB VPB VPWR Y
MMNnand0 VGND A sndNA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNnand1 sndNA B inand VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi10 nmid A VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi11 nmid B VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi20 Y inand nmid VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnand0 inand A VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnand1 inand B VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi10 VPWR A sndPA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi11 sndPA B Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi20 Y inand VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__xnor2_4 A B VGND VNB VPB VPWR Y
MMNnand0 VGND A sndNA VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNnand1 sndNA B inand VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi10 nmid A VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi11 nmid B VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi20 Y inand nmid VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnand0 inand A VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnand1 inand B VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi10 VPWR A sndPA VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi11 sndPA B Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi20 Y inand VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__xnor3_1 A B C VGND VNB VPB VPWR X
MMIN3 X net57 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI29 Ab Bb mid2 VNB nfet_01v8 m=1 w=0.6 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI25 Abb Bb mid1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 Bb B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 mid1 Cb net57 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 Ab A VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 Cb C VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI2 mid2 C net57 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI46 Abb Ab VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI24 Ab B mid1 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI28 Abb B mid2 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP3 X net57 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 mid1 C net57 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI27 mid2 B Ab VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 Abb Ab VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI23 mid1 B Abb VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI26 mid2 Bb Abb VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI7 mid2 Cb net57 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI33 Cb C VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 Ab A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI16 Bb B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 mid1 Bb Ab VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__xnor3_2 A B C VGND VNB VPB VPWR X
MMIN3 X net57 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI29 Ab Bb mid2 VNB nfet_01v8 m=1 w=0.6 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI25 Abb Bb mid1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 Bb B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 mid1 Cb net57 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 Ab A VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 Cb C VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI2 mid2 C net57 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI46 Abb Ab VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI24 Ab B mid1 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI28 Abb B mid2 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP3 X net57 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 mid1 C net57 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI27 mid2 B Ab VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 Abb Ab VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI23 mid1 B Abb VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI26 mid2 Bb Abb VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI7 mid2 Cb net57 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI33 Cb C VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 Ab A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI16 Bb B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 mid1 Bb Ab VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__xnor3_4 A B C VGND VNB VPB VPWR X
MMIN3 X net57 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI29 Ab Bb mid2 VNB nfet_01v8 m=1 w=0.6 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI25 Abb Bb mid1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 Bb B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 mid1 Cb net57 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 Ab A VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 Cb C VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI2 mid2 C net57 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI46 Abb Ab VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI24 Ab B mid1 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI28 Abb B mid2 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP3 X net57 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 mid1 C net57 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI27 mid2 B Ab VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 Abb Ab VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI23 mid1 B Abb VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI26 mid2 Bb Abb VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI7 mid2 Cb net57 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI33 Cb C VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 Ab A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI16 Bb B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 mid1 Bb Ab VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__xor2_1 A B VGND VNB VPB VPWR X
MMNnor0 inor A VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNnor1 inor B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi10 VGND A sndNA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi11 sndNA B X VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi20 X inor VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnor0 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnor1 sndPA B inor VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi10 pmid A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi11 pmid B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi20 X inor pmid VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__xor2_2 A B VGND VNB VPB VPWR X
MMNnor0 inor A VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNnor1 inor B VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi10 VGND A sndNA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi11 sndNA B X VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi20 X inor VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnor0 VPWR A sndPA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnor1 sndPA B inor VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi10 pmid A VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi11 pmid B VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi20 X inor pmid VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__xor2_4 A B VGND VNB VPB VPWR X
MMNnor0 inor A VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNnor1 inor B VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi10 VGND A sndNA VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi11 sndNA B X VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi20 X inor VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnor0 VPWR A sndPA VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnor1 sndPA B inor VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi10 pmid A VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi11 pmid B VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi20 X inor pmid VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__xor3_1 A B C VGND VNB VPB VPWR X
MMIP3 X net117 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 mid1 Cb net117 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI1 mid2 C net117 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI33 Cb C VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 Ab A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 Abb Ab VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 mid1 Bb Ab VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI16 Bb B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI23 mid1 B Abb VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI26 mid2 Bb Abb VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI27 mid2 B Ab VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 X net117 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 Cb C VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 mid1 C net117 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI2 mid2 Cb net117 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 Ab A VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI46 Abb Ab VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 Bb B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI24 Ab B mid1 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI25 Abb Bb mid1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI28 Abb B mid2 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI29 Ab Bb mid2 VNB nfet_01v8 m=1 w=0.6 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__xor3_2 A B C VGND VNB VPB VPWR X
MMIP3 X net117 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 mid1 Cb net117 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI1 mid2 C net117 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI33 Cb C VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 Ab A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 Abb Ab VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 mid1 Bb Ab VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI16 Bb B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI23 mid1 B Abb VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI26 mid2 Bb Abb VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI27 mid2 B Ab VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 X net117 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 Cb C VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 mid1 C net117 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI2 mid2 Cb net117 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 Ab A VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI46 Abb Ab VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 Bb B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI24 Ab B mid1 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI25 Abb Bb mid1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI28 Abb B mid2 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI29 Ab Bb mid2 VNB nfet_01v8 m=1 w=0.6 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__xor3_4 A B C VGND VNB VPB VPWR X
MMIP3 X net117 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 mid1 Cb net117 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI1 mid2 C net117 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI33 Cb C VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 Ab A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 Abb Ab VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 mid1 Bb Ab VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI16 Bb B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI23 mid1 B Abb VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI26 mid2 Bb Abb VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI27 mid2 B Ab VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 X net117 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 Cb C VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 mid1 C net117 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI2 mid2 Cb net117 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 Ab A VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI46 Abb Ab VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 Bb B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI24 Ab B mid1 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI25 Abb Bb mid1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI28 Abb B mid2 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI29 Ab Bb mid2 VNB nfet_01v8 m=1 w=0.6 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.subckt register VGND VPWR clk data_addr1[0] data_addr1[1] data_addr1[2] data_addr1[3]
+ data_addr1[4] data_addr2[0] data_addr2[1] data_addr2[2] data_addr2[3] data_addr2[4]
+ data_addr[0] data_addr[1] data_addr[2] data_addr[3] data_addr[4] data_in[0] data_in[10]
+ data_in[11] data_in[12] data_in[13] data_in[14] data_in[15] data_in[16] data_in[17]
+ data_in[18] data_in[19] data_in[1] data_in[20] data_in[21] data_in[22] data_in[23]
+ data_in[24] data_in[25] data_in[26] data_in[27] data_in[28] data_in[29] data_in[2]
+ data_in[30] data_in[31] data_in[3] data_in[4] data_in[5] data_in[6] data_in[7] data_in[8]
+ data_in[9] data_out1[0] data_out1[10] data_out1[11] data_out1[12] data_out1[13]
+ data_out1[14] data_out1[15] data_out1[16] data_out1[17] data_out1[18] data_out1[19]
+ data_out1[1] data_out1[20] data_out1[21] data_out1[22] data_out1[23] data_out1[24]
+ data_out1[25] data_out1[26] data_out1[27] data_out1[28] data_out1[29] data_out1[2]
+ data_out1[30] data_out1[31] data_out1[3] data_out1[4] data_out1[5] data_out1[6]
+ data_out1[7] data_out1[8] data_out1[9] data_out2[0] data_out2[10] data_out2[11]
+ data_out2[12] data_out2[13] data_out2[14] data_out2[15] data_out2[16] data_out2[17]
+ data_out2[18] data_out2[19] data_out2[1] data_out2[20] data_out2[21] data_out2[22]
+ data_out2[23] data_out2[24] data_out2[25] data_out2[26] data_out2[27] data_out2[28]
+ data_out2[29] data_out2[2] data_out2[30] data_out2[31] data_out2[3] data_out2[4]
+ data_out2[5] data_out2[6] data_out2[7] data_out2[8] data_out2[9] reset w_enable
XFILLER_0_96_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6914_ clknet_leaf_59_clk _0505_ VGND VGND VPWR VPWR memory\[15\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_77_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7894_ clknet_leaf_111_clk _0428_ VGND VGND VPWR VPWR memory\[17\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_49_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6776_ _2657_ _3434_ _3435_ net584 VGND VGND VPWR VPWR _0410_ sky130_fd_sc_hd__a22o_1
X_3988_ memory\[12\]\[24\] memory\[13\]\[24\] memory\[14\]\[24\] memory\[15\]\[24\]
+ _1188_ _1190_ VGND VGND VPWR VPWR _1670_ sky130_fd_sc_hd__mux4_1
XFILLER_0_91_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_57_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5727_ net1044 _2890_ _2880_ _2894_ VGND VGND VPWR VPWR _0895_ sky130_fd_sc_hd__a31o_1
XFILLER_0_33_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5658_ net1013 _2844_ _2833_ _2846_ VGND VGND VPWR VPWR _0874_ sky130_fd_sc_hd__a31o_1
X_4609_ _2260_ _2261_ _2191_ VGND VGND VPWR VPWR _2262_ sky130_fd_sc_hd__mux2_1
X_5589_ _2790_ VGND VGND VPWR VPWR _2804_ sky130_fd_sc_hd__buf_2
XFILLER_0_60_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold340 memory\[11\]\[20\] VGND VGND VPWR VPWR net549 sky130_fd_sc_hd__dlygate4sd3_1
Xhold362 memory\[11\]\[17\] VGND VGND VPWR VPWR net571 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_7_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold351 memory\[24\]\[12\] VGND VGND VPWR VPWR net560 sky130_fd_sc_hd__dlygate4sd3_1
X_7328_ clknet_leaf_83_clk _0887_ VGND VGND VPWR VPWR memory\[7\]\[17\] sky130_fd_sc_hd__dfxtp_1
Xhold373 memory\[5\]\[23\] VGND VGND VPWR VPWR net582 sky130_fd_sc_hd__dlygate4sd3_1
X_7259_ net162 _0003_ VGND VGND VPWR VPWR net85 sky130_fd_sc_hd__dfxtp_2
Xhold384 memory\[23\]\[3\] VGND VGND VPWR VPWR net593 sky130_fd_sc_hd__dlygate4sd3_1
Xhold395 memory\[7\]\[15\] VGND VGND VPWR VPWR net604 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_1800 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1833 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1822 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1811 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1866 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1855 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1844 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_70_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_48_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_59_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4960_ memory\[10\]\[10\] _2516_ _2526_ VGND VGND VPWR VPWR _2527_ sky130_fd_sc_hd__and3_1
XFILLER_0_86_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3911_ _1183_ VGND VGND VPWR VPWR _1597_ sky130_fd_sc_hd__clkbuf_4
X_4891_ _2456_ _2494_ _2496_ net751 VGND VGND VPWR VPWR _0488_ sky130_fd_sc_hd__a22o_1
XFILLER_0_59_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6630_ _2440_ _2441_ _2442_ _2491_ VGND VGND VPWR VPWR _3375_ sky130_fd_sc_hd__and4_1
XFILLER_0_58_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3842_ _1529_ _1530_ _1472_ VGND VGND VPWR VPWR _1531_ sky130_fd_sc_hd__mux2_1
XFILLER_0_46_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_116_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6561_ net851 _3346_ _3338_ _3350_ VGND VGND VPWR VPWR _0280_ sky130_fd_sc_hd__a31o_1
XFILLER_0_116_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5512_ _2775_ VGND VGND VPWR VPWR _2781_ sky130_fd_sc_hd__clkbuf_4
X_3773_ memory\[12\]\[13\] memory\[13\]\[13\] memory\[14\]\[13\] memory\[15\]\[13\]
+ _1430_ _1431_ VGND VGND VPWR VPWR _1466_ sky130_fd_sc_hd__mux4_2
XFILLER_0_54_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_89_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6492_ _2886_ _3308_ VGND VGND VPWR VPWR _3311_ sky130_fd_sc_hd__and2_1
XFILLER_0_80_7 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5443_ _2488_ _2757_ _2759_ net248 VGND VGND VPWR VPWR _0773_ sky130_fd_sc_hd__a22o_1
XFILLER_0_42_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_120_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_112_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5374_ _2460_ _2749_ _2751_ net250 VGND VGND VPWR VPWR _0717_ sky130_fd_sc_hd__a22o_1
X_7113_ clknet_leaf_35_clk _0704_ VGND VGND VPWR VPWR memory\[29\]\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_10_453 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4325_ _1964_ _1991_ _1968_ VGND VGND VPWR VPWR _1992_ sky130_fd_sc_hd__o21a_1
X_7044_ clknet_leaf_38_clk _0635_ VGND VGND VPWR VPWR memory\[16\]\[21\] sky130_fd_sc_hd__dfxtp_1
X_4256_ memory\[28\]\[4\] memory\[29\]\[4\] memory\[30\]\[4\] memory\[31\]\[4\] _1821_
+ _1822_ VGND VGND VPWR VPWR _1926_ sky130_fd_sc_hd__mux4_1
X_4187_ _1820_ _1859_ _1824_ VGND VGND VPWR VPWR _1860_ sky130_fd_sc_hd__o21a_1
XFILLER_0_96_217 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_77_431 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7946_ net209 _0051_ VGND VGND VPWR VPWR net69 sky130_fd_sc_hd__dfxtp_2
XTAP_1107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7877_ clknet_leaf_58_clk _0411_ VGND VGND VPWR VPWR memory\[13\]\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_65_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6759_ _2625_ _3429_ _3431_ net758 VGND VGND VPWR VPWR _0397_ sky130_fd_sc_hd__a22o_1
XFILLER_0_103_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold170 memory\[2\]\[18\] VGND VGND VPWR VPWR net379 sky130_fd_sc_hd__dlygate4sd3_1
Xhold192 memory\[14\]\[27\] VGND VGND VPWR VPWR net401 sky130_fd_sc_hd__dlygate4sd3_1
Xhold181 memory\[24\]\[20\] VGND VGND VPWR VPWR net390 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_18_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5559__34 clknet_1_1__leaf__2786_ VGND VGND VPWR VPWR net179 sky130_fd_sc_hd__inv_2
XTAP_1696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_59_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5090_ _2602_ VGND VGND VPWR VPWR _2603_ sky130_fd_sc_hd__clkbuf_4
X_4110_ _1250_ _1784_ _1254_ VGND VGND VPWR VPWR _1785_ sky130_fd_sc_hd__o21a_1
X_4041_ _1168_ _1719_ VGND VGND VPWR VPWR _1720_ sky130_fd_sc_hd__or2_1
XFILLER_0_75_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5992_ _2881_ _3036_ VGND VGND VPWR VPWR _3037_ sky130_fd_sc_hd__and2_1
X_7800_ clknet_leaf_19_clk _0334_ VGND VGND VPWR VPWR memory\[12\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_59_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4943_ _2455_ _2505_ _2517_ VGND VGND VPWR VPWR _0520_ sky130_fd_sc_hd__a21o_1
X_7731_ clknet_leaf_115_clk _0265_ VGND VGND VPWR VPWR memory\[22\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_115_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_86_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7662_ clknet_leaf_16_clk _0196_ VGND VGND VPWR VPWR memory\[19\]\[31\] sky130_fd_sc_hd__dfxtp_1
X_4874_ net37 VGND VGND VPWR VPWR _2486_ sky130_fd_sc_hd__buf_4
X_6613_ _2646_ _3371_ _3372_ net405 VGND VGND VPWR VPWR _0310_ sky130_fd_sc_hd__a22o_1
XFILLER_0_46_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_105_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_7593_ clknet_leaf_24_clk _1152_ VGND VGND VPWR VPWR memory\[23\]\[26\] sky130_fd_sc_hd__dfxtp_1
X_3825_ _1394_ _1514_ VGND VGND VPWR VPWR _1515_ sky130_fd_sc_hd__or2_1
XFILLER_0_27_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_4_12_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_12_0_clk sky130_fd_sc_hd__clkbuf_8
X_6544_ net985 _3333_ _3338_ _3341_ VGND VGND VPWR VPWR _0272_ sky130_fd_sc_hd__a31o_1
X_3756_ _1448_ _1449_ _1205_ VGND VGND VPWR VPWR _1450_ sky130_fd_sc_hd__mux2_1
X_6475_ _2870_ _3295_ VGND VGND VPWR VPWR _3301_ sky130_fd_sc_hd__and2_1
XFILLER_0_42_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3687_ _1193_ _1383_ _1197_ VGND VGND VPWR VPWR _1384_ sky130_fd_sc_hd__o21a_1
X_5426_ _2471_ _2761_ _2762_ net358 VGND VGND VPWR VPWR _0758_ sky130_fd_sc_hd__a22o_1
XFILLER_0_2_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5357_ _2485_ _2744_ _2745_ net431 VGND VGND VPWR VPWR _0706_ sky130_fd_sc_hd__a22o_1
XFILLER_0_100_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4308_ _1808_ VGND VGND VPWR VPWR _1976_ sky130_fd_sc_hd__buf_8
X_5288_ net1027 _2717_ _2707_ _2718_ VGND VGND VPWR VPWR _0664_ sky130_fd_sc_hd__a31o_1
X_7027_ clknet_leaf_113_clk _0618_ VGND VGND VPWR VPWR memory\[16\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_4239_ memory\[4\]\[3\] memory\[5\]\[3\] memory\[6\]\[3\] memory\[7\]\[3\] _1863_
+ _1864_ VGND VGND VPWR VPWR _1910_ sky130_fd_sc_hd__mux4_1
XFILLER_0_97_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7929_ net192 _0033_ VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__dfxtp_2
XFILLER_0_108_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_103_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_548 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6831__40 clknet_1_1__leaf__2787_ VGND VGND VPWR VPWR net185 sky130_fd_sc_hd__inv_2
XFILLER_0_75_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4590_ _2242_ _2243_ _2191_ VGND VGND VPWR VPWR _2244_ sky130_fd_sc_hd__mux2_1
XFILLER_0_9_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_37_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3610_ _1302_ _1310_ VGND VGND VPWR VPWR _1311_ sky130_fd_sc_hd__and2_1
X_3541_ _1168_ VGND VGND VPWR VPWR _1245_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_52_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold928 memory\[25\]\[26\] VGND VGND VPWR VPWR net1137 sky130_fd_sc_hd__dlygate4sd3_1
Xhold917 memory\[6\]\[23\] VGND VGND VPWR VPWR net1126 sky130_fd_sc_hd__dlygate4sd3_1
Xhold906 memory\[10\]\[30\] VGND VGND VPWR VPWR net1115 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_10_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_110_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6260_ net421 _3187_ _3182_ _3191_ VGND VGND VPWR VPWR _0138_ sky130_fd_sc_hd__a31o_1
Xhold939 memory\[6\]\[14\] VGND VGND VPWR VPWR net1148 sky130_fd_sc_hd__dlygate4sd3_1
X_3472_ _1170_ VGND VGND VPWR VPWR _1178_ sky130_fd_sc_hd__buf_4
X_6191_ net596 _3146_ _3138_ _3151_ VGND VGND VPWR VPWR _1134_ sky130_fd_sc_hd__a31o_1
X_5211_ _2459_ _2683_ _2685_ net363 VGND VGND VPWR VPWR _0620_ sky130_fd_sc_hd__a22o_1
X_5142_ _2640_ _2632_ VGND VGND VPWR VPWR _2641_ sky130_fd_sc_hd__and2_1
X_5073_ _2482_ _2584_ _2592_ VGND VGND VPWR VPWR _0575_ sky130_fd_sc_hd__a21o_1
X_4024_ _1702_ _1703_ _1521_ VGND VGND VPWR VPWR _1704_ sky130_fd_sc_hd__mux2_1
XFILLER_0_79_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5975_ _2865_ _3023_ VGND VGND VPWR VPWR _3027_ sky130_fd_sc_hd__and2_1
XFILLER_0_47_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4926_ _2443_ _2445_ _2444_ VGND VGND VPWR VPWR _2503_ sky130_fd_sc_hd__or3b_1
X_7714_ clknet_leaf_82_clk _0248_ VGND VGND VPWR VPWR memory\[5\]\[19\] sky130_fd_sc_hd__dfxtp_1
X_4857_ _2475_ _2476_ _2477_ net657 VGND VGND VPWR VPWR _0473_ sky130_fd_sc_hd__a22o_1
XFILLER_0_90_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_7645_ clknet_leaf_89_clk _0179_ VGND VGND VPWR VPWR memory\[19\]\[14\] sky130_fd_sc_hd__dfxtp_1
X_7576_ clknet_leaf_110_clk _1135_ VGND VGND VPWR VPWR memory\[23\]\[9\] sky130_fd_sc_hd__dfxtp_1
X_3808_ _1390_ _1494_ _1496_ _1498_ _1403_ VGND VGND VPWR VPWR _1499_ sky130_fd_sc_hd__a221o_1
X_4788_ _1959_ _2430_ VGND VGND VPWR VPWR _2431_ sky130_fd_sc_hd__or2_1
X_6527_ net685 _3317_ _3324_ _3331_ VGND VGND VPWR VPWR _0265_ sky130_fd_sc_hd__a31o_1
X_3739_ _1236_ _1425_ _1429_ _1433_ _1412_ VGND VGND VPWR VPWR _1434_ sky130_fd_sc_hd__a221o_1
XFILLER_0_15_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6458_ _2508_ VGND VGND VPWR VPWR _3291_ sky130_fd_sc_hd__buf_4
X_6389_ _2858_ _3251_ VGND VGND VPWR VPWR _3252_ sky130_fd_sc_hd__and2_1
X_5409_ _2454_ _2758_ _2760_ net239 VGND VGND VPWR VPWR _0743_ sky130_fd_sc_hd__a22o_1
XFILLER_0_97_301 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_38_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_104_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5760_ _2625_ _2910_ _2912_ net778 VGND VGND VPWR VPWR _0910_ sky130_fd_sc_hd__a22o_1
X_4711_ _2113_ _2357_ VGND VGND VPWR VPWR _2358_ sky130_fd_sc_hd__or2_1
XTAP_1290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5691_ net527 _2867_ _2857_ _2869_ VGND VGND VPWR VPWR _0884_ sky130_fd_sc_hd__a31o_1
X_7430_ clknet_leaf_57_clk net122 VGND VGND VPWR VPWR memory\[0\]\[23\] sky130_fd_sc_hd__dfxtp_1
X_4642_ _2287_ _2289_ _2292_ _1862_ _2223_ VGND VGND VPWR VPWR _2293_ sky130_fd_sc_hd__a221o_1
XFILLER_0_84_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_114_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4573_ _1976_ _2227_ _1796_ VGND VGND VPWR VPWR _2228_ sky130_fd_sc_hd__o21a_1
Xhold703 memory\[20\]\[14\] VGND VGND VPWR VPWR net912 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_25_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7361_ clknet_leaf_98_clk _0920_ VGND VGND VPWR VPWR memory\[18\]\[18\] sky130_fd_sc_hd__dfxtp_1
Xhold736 memory\[26\]\[29\] VGND VGND VPWR VPWR net945 sky130_fd_sc_hd__dlygate4sd3_1
X_6312_ net870 _3213_ _3209_ _3220_ VGND VGND VPWR VPWR _0161_ sky130_fd_sc_hd__a31o_1
X_7292_ clknet_leaf_70_clk _0851_ VGND VGND VPWR VPWR memory\[8\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_12_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3524_ memory\[20\]\[2\] memory\[21\]\[2\] memory\[22\]\[2\] memory\[23\]\[2\] _1157_
+ _1159_ VGND VGND VPWR VPWR _1228_ sky130_fd_sc_hd__mux4_1
XFILLER_0_4_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold725 memory\[20\]\[0\] VGND VGND VPWR VPWR net934 sky130_fd_sc_hd__dlygate4sd3_1
Xhold714 memory\[26\]\[9\] VGND VGND VPWR VPWR net923 sky130_fd_sc_hd__dlygate4sd3_1
Xhold758 memory\[4\]\[20\] VGND VGND VPWR VPWR net967 sky130_fd_sc_hd__dlygate4sd3_1
Xhold747 memory\[12\]\[30\] VGND VGND VPWR VPWR net956 sky130_fd_sc_hd__dlygate4sd3_1
Xhold769 memory\[16\]\[28\] VGND VGND VPWR VPWR net978 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3455_ _1156_ VGND VGND VPWR VPWR _1161_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_40_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6243_ net902 _3172_ _3137_ _3180_ VGND VGND VPWR VPWR _0132_ sky130_fd_sc_hd__a31o_1
X_6174_ _2838_ _3140_ VGND VGND VPWR VPWR _3142_ sky130_fd_sc_hd__and2_1
X_5125_ net923 _2601_ _2606_ _2628_ VGND VGND VPWR VPWR _0591_ sky130_fd_sc_hd__a31o_1
X_5056_ _2473_ _2571_ _2582_ VGND VGND VPWR VPWR _0568_ sky130_fd_sc_hd__a21o_1
X_4007_ memory\[8\]\[25\] memory\[9\]\[25\] memory\[10\]\[25\] memory\[11\]\[25\]
+ _1426_ _1427_ VGND VGND VPWR VPWR _1688_ sky130_fd_sc_hd__mux4_1
XFILLER_0_62_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5958_ _2849_ _3010_ VGND VGND VPWR VPWR _3017_ sky130_fd_sc_hd__and2_1
XFILLER_0_47_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4909_ _2474_ _2497_ _2498_ net234 VGND VGND VPWR VPWR _0504_ sky130_fd_sc_hd__a22o_1
XFILLER_0_90_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5889_ net458 _2968_ _2963_ _2976_ VGND VGND VPWR VPWR _1007_ sky130_fd_sc_hd__a31o_1
X_7628_ clknet_leaf_28_clk _0162_ VGND VGND VPWR VPWR memory\[27\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_90_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7559_ clknet_leaf_26_clk _1118_ VGND VGND VPWR VPWR memory\[20\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_62_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_113_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold41 memory\[3\]\[7\] VGND VGND VPWR VPWR net250 sky130_fd_sc_hd__dlygate4sd3_1
Xhold30 memory\[2\]\[1\] VGND VGND VPWR VPWR net239 sky130_fd_sc_hd__dlygate4sd3_1
Xhold63 memory\[31\]\[21\] VGND VGND VPWR VPWR net272 sky130_fd_sc_hd__dlygate4sd3_1
Xhold74 memory\[13\]\[20\] VGND VGND VPWR VPWR net283 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_89_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold52 memory\[30\]\[19\] VGND VGND VPWR VPWR net261 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_98_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold85 memory\[15\]\[31\] VGND VGND VPWR VPWR net294 sky130_fd_sc_hd__dlygate4sd3_1
Xhold96 memory\[19\]\[10\] VGND VGND VPWR VPWR net305 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_85_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_108_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_109_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_53_267 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XANTENNA_5 _1170_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_548 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6930_ clknet_leaf_16_clk _0521_ VGND VGND VPWR VPWR memory\[10\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_16_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_49_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_119_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6792_ _2607_ _3438_ _3440_ net359 VGND VGND VPWR VPWR _0421_ sky130_fd_sc_hd__a22o_1
X_5812_ net1124 _2930_ _2921_ VGND VGND VPWR VPWR _2932_ sky130_fd_sc_hd__and3_1
XFILLER_0_91_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5743_ net40 VGND VGND VPWR VPWR _2905_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_57_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5674_ _2832_ VGND VGND VPWR VPWR _2857_ sky130_fd_sc_hd__clkbuf_4
X_4625_ memory\[8\]\[22\] memory\[9\]\[22\] memory\[10\]\[22\] memory\[11\]\[22\]
+ _1948_ _1949_ VGND VGND VPWR VPWR _2277_ sky130_fd_sc_hd__mux4_1
X_7413_ clknet_leaf_103_clk net139 VGND VGND VPWR VPWR memory\[0\]\[6\] sky130_fd_sc_hd__dfxtp_1
Xhold500 memory\[28\]\[31\] VGND VGND VPWR VPWR net709 sky130_fd_sc_hd__dlygate4sd3_1
X_4556_ memory\[12\]\[18\] memory\[13\]\[18\] memory\[14\]\[18\] memory\[15\]\[18\]
+ _2045_ _2046_ VGND VGND VPWR VPWR _2212_ sky130_fd_sc_hd__mux4_1
Xhold511 memory\[21\]\[12\] VGND VGND VPWR VPWR net720 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7344_ clknet_leaf_116_clk _0903_ VGND VGND VPWR VPWR memory\[18\]\[1\] sky130_fd_sc_hd__dfxtp_1
Xhold544 memory\[11\]\[29\] VGND VGND VPWR VPWR net753 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3507_ memory\[16\]\[1\] memory\[17\]\[1\] memory\[18\]\[1\] memory\[19\]\[1\] _1161_
+ _1162_ VGND VGND VPWR VPWR _1212_ sky130_fd_sc_hd__mux4_1
Xhold522 memory\[27\]\[9\] VGND VGND VPWR VPWR net731 sky130_fd_sc_hd__dlygate4sd3_1
Xhold533 memory\[4\]\[6\] VGND VGND VPWR VPWR net742 sky130_fd_sc_hd__dlygate4sd3_1
Xhold588 memory\[12\]\[21\] VGND VGND VPWR VPWR net797 sky130_fd_sc_hd__dlygate4sd3_1
Xhold566 memory\[21\]\[27\] VGND VGND VPWR VPWR net775 sky130_fd_sc_hd__dlygate4sd3_1
Xhold577 memory\[1\]\[25\] VGND VGND VPWR VPWR net786 sky130_fd_sc_hd__dlygate4sd3_1
X_7275_ net178 _0020_ VGND VGND VPWR VPWR net102 sky130_fd_sc_hd__dfxtp_2
Xhold555 memory\[4\]\[8\] VGND VGND VPWR VPWR net764 sky130_fd_sc_hd__dlygate4sd3_1
X_4487_ _2146_ VGND VGND VPWR VPWR _0037_ sky130_fd_sc_hd__clkbuf_1
Xhold599 memory\[3\]\[29\] VGND VGND VPWR VPWR net808 sky130_fd_sc_hd__dlygate4sd3_1
X_6226_ net924 _3159_ _3166_ _3171_ VGND VGND VPWR VPWR _1149_ sky130_fd_sc_hd__a31o_1
X_6157_ net648 _3130_ _3122_ _3131_ VGND VGND VPWR VPWR _1120_ sky130_fd_sc_hd__a31o_1
XTAP_871 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_860 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_882 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_893 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5108_ net42 VGND VGND VPWR VPWR _2617_ sky130_fd_sc_hd__buf_4
X_6088_ _2903_ _3052_ VGND VGND VPWR VPWR _3091_ sky130_fd_sc_hd__and2_1
X_5039_ net1132 _2572_ _2573_ VGND VGND VPWR VPWR _2574_ sky130_fd_sc_hd__and3_1
XFILLER_0_95_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_212 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_8_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_114_clk clknet_4_0_0_clk VGND VGND VPWR VPWR clknet_leaf_114_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_106_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_121_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput75 net75 VGND VGND VPWR VPWR data_out1[3] sky130_fd_sc_hd__buf_2
Xoutput53 net53 VGND VGND VPWR VPWR data_out1[12] sky130_fd_sc_hd__clkbuf_4
Xoutput64 net64 VGND VGND VPWR VPWR data_out1[22] sky130_fd_sc_hd__clkbuf_4
Xoutput97 net97 VGND VGND VPWR VPWR data_out2[23] sky130_fd_sc_hd__clkbuf_4
Xoutput86 net86 VGND VGND VPWR VPWR data_out2[13] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_86_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_85_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_109_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_105_clk clknet_4_1_0_clk VGND VGND VPWR VPWR clknet_leaf_105_clk sky130_fd_sc_hd__clkbuf_16
X_4410_ memory\[20\]\[11\] memory\[21\]\[11\] memory\[22\]\[11\] memory\[23\]\[11\]
+ _1831_ _1833_ VGND VGND VPWR VPWR _2073_ sky130_fd_sc_hd__mux4_1
X_5390_ _2750_ VGND VGND VPWR VPWR _2755_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_78_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_111_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4341_ _1959_ _2006_ VGND VGND VPWR VPWR _2007_ sky130_fd_sc_hd__or2_1
XFILLER_0_120_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_10_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4272_ memory\[16\]\[5\] memory\[17\]\[5\] memory\[18\]\[5\] memory\[19\]\[5\] _1804_
+ _1805_ VGND VGND VPWR VPWR _1941_ sky130_fd_sc_hd__mux4_1
X_7060_ clknet_leaf_112_clk _0651_ VGND VGND VPWR VPWR memory\[4\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_6011_ net804 _3034_ _3035_ _3046_ VGND VGND VPWR VPWR _1059_ sky130_fd_sc_hd__a31o_1
XFILLER_0_118_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6913_ clknet_leaf_66_clk _0504_ VGND VGND VPWR VPWR memory\[15\]\[19\] sky130_fd_sc_hd__dfxtp_1
X_7893_ clknet_leaf_114_clk _0427_ VGND VGND VPWR VPWR memory\[17\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_119_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6775_ _2654_ _3434_ _3435_ net283 VGND VGND VPWR VPWR _0409_ sky130_fd_sc_hd__a22o_1
X_3987_ _1168_ _1668_ VGND VGND VPWR VPWR _1669_ sky130_fd_sc_hd__or2_1
XFILLER_0_9_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5726_ _2893_ _2882_ VGND VGND VPWR VPWR _2894_ sky130_fd_sc_hd__and2_1
XFILLER_0_33_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_103_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5657_ _2845_ _2836_ VGND VGND VPWR VPWR _2846_ sky130_fd_sc_hd__and2_1
XFILLER_0_32_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_102_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4608_ memory\[0\]\[21\] memory\[1\]\[21\] memory\[2\]\[21\] memory\[3\]\[21\] _2017_
+ _2018_ VGND VGND VPWR VPWR _2261_ sky130_fd_sc_hd__mux4_1
X_5588_ _2788_ VGND VGND VPWR VPWR _2803_ sky130_fd_sc_hd__clkbuf_4
X_4539_ _2104_ _2195_ _2106_ VGND VGND VPWR VPWR _2196_ sky130_fd_sc_hd__o21a_1
Xhold352 memory\[13\]\[13\] VGND VGND VPWR VPWR net561 sky130_fd_sc_hd__dlygate4sd3_1
Xhold330 memory\[8\]\[1\] VGND VGND VPWR VPWR net539 sky130_fd_sc_hd__dlygate4sd3_1
X_7327_ clknet_leaf_83_clk _0886_ VGND VGND VPWR VPWR memory\[7\]\[16\] sky130_fd_sc_hd__dfxtp_1
Xhold341 memory\[31\]\[14\] VGND VGND VPWR VPWR net550 sky130_fd_sc_hd__dlygate4sd3_1
Xhold363 memory\[15\]\[14\] VGND VGND VPWR VPWR net572 sky130_fd_sc_hd__dlygate4sd3_1
X_7258_ net161 _0002_ VGND VGND VPWR VPWR net84 sky130_fd_sc_hd__dfxtp_2
Xhold385 memory\[5\]\[18\] VGND VGND VPWR VPWR net594 sky130_fd_sc_hd__dlygate4sd3_1
Xhold396 memory\[19\]\[2\] VGND VGND VPWR VPWR net605 sky130_fd_sc_hd__dlygate4sd3_1
Xhold374 memory\[11\]\[8\] VGND VGND VPWR VPWR net583 sky130_fd_sc_hd__dlygate4sd3_1
X_6209_ _2872_ _3154_ VGND VGND VPWR VPWR _3162_ sky130_fd_sc_hd__and2_1
X_7189_ clknet_leaf_20_clk _0780_ VGND VGND VPWR VPWR memory\[14\]\[6\] sky130_fd_sc_hd__dfxtp_1
XTAP_690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1834 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1823 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1801 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1812 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1867 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1856 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1845 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_106_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6838__46 clknet_1_1__leaf__3445_ VGND VGND VPWR VPWR net191 sky130_fd_sc_hd__inv_2
XFILLER_0_31_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3910_ _1591_ _1594_ _1595_ VGND VGND VPWR VPWR _1596_ sky130_fd_sc_hd__o21a_1
XFILLER_0_74_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4890_ _2455_ _2494_ _2496_ net438 VGND VGND VPWR VPWR _0487_ sky130_fd_sc_hd__a22o_1
XFILLER_0_46_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3841_ memory\[16\]\[17\] memory\[17\]\[17\] memory\[18\]\[17\] memory\[19\]\[17\]
+ _1349_ _1350_ VGND VGND VPWR VPWR _1530_ sky130_fd_sc_hd__mux4_1
XFILLER_0_73_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3772_ _1245_ _1464_ VGND VGND VPWR VPWR _1465_ sky130_fd_sc_hd__or2_1
X_6560_ _2878_ _3339_ VGND VGND VPWR VPWR _3350_ sky130_fd_sc_hd__and2_1
XFILLER_0_54_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_587 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5511_ _2650_ _2779_ _2780_ net351 VGND VGND VPWR VPWR _0825_ sky130_fd_sc_hd__a22o_1
X_6491_ net409 _3304_ _3307_ _3310_ VGND VGND VPWR VPWR _0250_ sky130_fd_sc_hd__a31o_1
XFILLER_0_82_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_120_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5442_ _2487_ _2757_ _2759_ net535 VGND VGND VPWR VPWR _0772_ sky130_fd_sc_hd__a22o_1
XFILLER_0_1_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5373_ _2459_ _2749_ _2751_ net278 VGND VGND VPWR VPWR _0716_ sky130_fd_sc_hd__a22o_1
X_7112_ clknet_leaf_36_clk _0703_ VGND VGND VPWR VPWR memory\[29\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_10_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4324_ memory\[28\]\[7\] memory\[29\]\[7\] memory\[30\]\[7\] memory\[31\]\[7\] _1965_
+ _1966_ VGND VGND VPWR VPWR _1991_ sky130_fd_sc_hd__mux4_2
X_7043_ clknet_leaf_34_clk _0634_ VGND VGND VPWR VPWR memory\[16\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_10_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4255_ _1812_ _1924_ VGND VGND VPWR VPWR _1925_ sky130_fd_sc_hd__or2_1
X_4186_ memory\[28\]\[1\] memory\[29\]\[1\] memory\[30\]\[1\] memory\[31\]\[1\] _1821_
+ _1822_ VGND VGND VPWR VPWR _1859_ sky130_fd_sc_hd__mux4_1
XFILLER_0_89_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7945_ net208 _0050_ VGND VGND VPWR VPWR net68 sky130_fd_sc_hd__dfxtp_2
XTAP_1119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1108 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7876_ clknet_leaf_54_clk _0410_ VGND VGND VPWR VPWR memory\[13\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_77_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6827_ _2678_ _3437_ _3439_ net841 VGND VGND VPWR VPWR _0452_ sky130_fd_sc_hd__a22o_1
XFILLER_0_18_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6758_ _2623_ _3429_ _3431_ net835 VGND VGND VPWR VPWR _0396_ sky130_fd_sc_hd__a22o_1
X_5709_ _2835_ VGND VGND VPWR VPWR _2882_ sky130_fd_sc_hd__buf_2
XFILLER_0_60_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6689_ net44 _3388_ VGND VGND VPWR VPWR _3396_ sky130_fd_sc_hd__and2_1
XFILLER_0_60_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_568 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_20_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold160 memory\[2\]\[26\] VGND VGND VPWR VPWR net369 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold171 memory\[11\]\[14\] VGND VGND VPWR VPWR net380 sky130_fd_sc_hd__dlygate4sd3_1
Xhold182 memory\[19\]\[24\] VGND VGND VPWR VPWR net391 sky130_fd_sc_hd__dlygate4sd3_1
Xhold193 memory\[5\]\[31\] VGND VGND VPWR VPWR net402 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_34_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4040_ memory\[8\]\[27\] memory\[9\]\[27\] memory\[10\]\[27\] memory\[11\]\[27\]
+ _1202_ _1203_ VGND VGND VPWR VPWR _1719_ sky130_fd_sc_hd__mux4_1
X_5991_ _3009_ VGND VGND VPWR VPWR _3036_ sky130_fd_sc_hd__buf_2
XFILLER_0_91_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4942_ net1158 _2516_ _2513_ VGND VGND VPWR VPWR _2517_ sky130_fd_sc_hd__and3_1
X_7730_ clknet_leaf_115_clk _0264_ VGND VGND VPWR VPWR memory\[22\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_7661_ clknet_leaf_40_clk _0195_ VGND VGND VPWR VPWR memory\[19\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_47_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4873_ _2485_ _2476_ _2477_ net581 VGND VGND VPWR VPWR _0481_ sky130_fd_sc_hd__a22o_1
X_6612_ _2644_ _3371_ _3372_ net334 VGND VGND VPWR VPWR _0309_ sky130_fd_sc_hd__a22o_1
X_7592_ clknet_leaf_28_clk _1151_ VGND VGND VPWR VPWR memory\[23\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_55_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3824_ memory\[24\]\[16\] memory\[25\]\[16\] memory\[26\]\[16\] memory\[27\]\[16\]
+ _1353_ _1354_ VGND VGND VPWR VPWR _1514_ sky130_fd_sc_hd__mux4_1
X_6543_ _2861_ _3339_ VGND VGND VPWR VPWR _3341_ sky130_fd_sc_hd__and2_1
X_3755_ memory\[0\]\[12\] memory\[1\]\[12\] memory\[2\]\[12\] memory\[3\]\[12\] _1271_
+ _1272_ VGND VGND VPWR VPWR _1449_ sky130_fd_sc_hd__mux4_1
XFILLER_0_113_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3686_ memory\[12\]\[9\] memory\[13\]\[9\] memory\[14\]\[9\] memory\[15\]\[9\] _1194_
+ _1195_ VGND VGND VPWR VPWR _1383_ sky130_fd_sc_hd__mux4_1
XFILLER_0_15_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6474_ net936 _3291_ _3294_ _3300_ VGND VGND VPWR VPWR _0243_ sky130_fd_sc_hd__a31o_1
XFILLER_0_40_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5425_ _2470_ _2761_ _2762_ net399 VGND VGND VPWR VPWR _0757_ sky130_fd_sc_hd__a22o_1
XFILLER_0_64_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5356_ _2484_ _2744_ _2745_ net378 VGND VGND VPWR VPWR _0705_ sky130_fd_sc_hd__a22o_1
XFILLER_0_10_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4307_ memory\[16\]\[6\] memory\[17\]\[6\] memory\[18\]\[6\] memory\[19\]\[6\] _1973_
+ _1974_ VGND VGND VPWR VPWR _1975_ sky130_fd_sc_hd__mux4_1
X_5287_ _2648_ _2708_ VGND VGND VPWR VPWR _2718_ sky130_fd_sc_hd__and2_1
X_7026_ clknet_leaf_2_clk _0617_ VGND VGND VPWR VPWR memory\[16\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_4238_ _1798_ _1904_ _1906_ _1908_ _1827_ VGND VGND VPWR VPWR _1909_ sky130_fd_sc_hd__a221o_1
XFILLER_0_4_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_94_clk clknet_4_4_0_clk VGND VGND VPWR VPWR clknet_leaf_94_clk sky130_fd_sc_hd__clkbuf_16
X_4169_ _1801_ VGND VGND VPWR VPWR _1843_ sky130_fd_sc_hd__clkbuf_8
X_7928_ net191 _0063_ VGND VGND VPWR VPWR net81 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_38_605 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_93_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_711 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7859_ clknet_leaf_22_clk _0393_ VGND VGND VPWR VPWR memory\[13\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_92_276 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_60_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_527 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_29_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_85_clk clknet_4_7_0_clk VGND VGND VPWR VPWR clknet_leaf_85_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_88_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3540_ _1239_ _1242_ _1243_ VGND VGND VPWR VPWR _1244_ sky130_fd_sc_hd__mux2_1
XFILLER_0_52_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold907 memory\[25\]\[21\] VGND VGND VPWR VPWR net1116 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_10_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold918 memory\[6\]\[6\] VGND VGND VPWR VPWR net1127 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_52_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_110_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_101_88 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5210_ _2458_ _2683_ _2685_ net823 VGND VGND VPWR VPWR _0619_ sky130_fd_sc_hd__a22o_1
Xhold929 memory\[6\]\[13\] VGND VGND VPWR VPWR net1138 sky130_fd_sc_hd__dlygate4sd3_1
X_3471_ _1176_ VGND VGND VPWR VPWR _1177_ sky130_fd_sc_hd__clkbuf_4
X_6190_ _2853_ _3140_ VGND VGND VPWR VPWR _3151_ sky130_fd_sc_hd__and2_1
X_5141_ net21 VGND VGND VPWR VPWR _2640_ sky130_fd_sc_hd__buf_4
X_5072_ net1147 _2585_ _2586_ VGND VGND VPWR VPWR _2592_ sky130_fd_sc_hd__and3_1
X_4023_ memory\[0\]\[26\] memory\[1\]\[26\] memory\[2\]\[26\] memory\[3\]\[26\] _1237_
+ _1238_ VGND VGND VPWR VPWR _1703_ sky130_fd_sc_hd__mux4_1
Xclkbuf_leaf_76_clk clknet_4_6_0_clk VGND VGND VPWR VPWR clknet_leaf_76_clk sky130_fd_sc_hd__clkbuf_16
X_7713_ clknet_leaf_80_clk _0247_ VGND VGND VPWR VPWR memory\[5\]\[18\] sky130_fd_sc_hd__dfxtp_1
X_5974_ net560 _3021_ _3022_ _3026_ VGND VGND VPWR VPWR _1042_ sky130_fd_sc_hd__a31o_1
X_4925_ _2489_ _2501_ VGND VGND VPWR VPWR _2502_ sky130_fd_sc_hd__nand2_2
X_4856_ _2452_ VGND VGND VPWR VPWR _2477_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_74_276 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_7_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7644_ clknet_leaf_88_clk _0178_ VGND VGND VPWR VPWR memory\[19\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_62_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7575_ clknet_leaf_110_clk _1134_ VGND VGND VPWR VPWR memory\[23\]\[8\] sky130_fd_sc_hd__dfxtp_1
X_3807_ _1397_ _1497_ _1401_ VGND VGND VPWR VPWR _1498_ sky130_fd_sc_hd__o21a_1
XFILLER_0_34_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4787_ memory\[8\]\[31\] memory\[9\]\[31\] memory\[10\]\[31\] memory\[11\]\[31\]
+ _1960_ _1961_ VGND VGND VPWR VPWR _2430_ sky130_fd_sc_hd__mux4_1
X_6526_ _2845_ _3326_ VGND VGND VPWR VPWR _3331_ sky130_fd_sc_hd__and2_1
X_3738_ _1250_ _1432_ _1254_ VGND VGND VPWR VPWR _1433_ sky130_fd_sc_hd__o21a_1
XFILLER_0_113_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3669_ memory\[8\]\[8\] memory\[9\]\[8\] memory\[10\]\[8\] memory\[11\]\[8\] _1246_
+ _1247_ VGND VGND VPWR VPWR _1367_ sky130_fd_sc_hd__mux4_1
X_6457_ net897 _3275_ _3280_ _3290_ VGND VGND VPWR VPWR _0236_ sky130_fd_sc_hd__a31o_1
X_6388_ _3237_ VGND VGND VPWR VPWR _3251_ sky130_fd_sc_hd__buf_2
X_5408_ _2439_ _2758_ _2760_ net710 VGND VGND VPWR VPWR _0742_ sky130_fd_sc_hd__a22o_1
X_5339_ _2467_ _2742_ _2743_ net861 VGND VGND VPWR VPWR _0690_ sky130_fd_sc_hd__a22o_1
Xclkbuf_leaf_67_clk clknet_4_13_0_clk VGND VGND VPWR VPWR clknet_leaf_67_clk sky130_fd_sc_hd__clkbuf_16
X_7009_ clknet_leaf_99_clk _0600_ VGND VGND VPWR VPWR memory\[26\]\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_97_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_93_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_287 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_108_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_58_clk clknet_4_15_0_clk VGND VGND VPWR VPWR clknet_leaf_58_clk sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_11_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_11_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_72_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_96_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4710_ memory\[24\]\[27\] memory\[25\]\[27\] memory\[26\]\[27\] memory\[27\]\[27\]
+ _1877_ _1878_ VGND VGND VPWR VPWR _2357_ sky130_fd_sc_hd__mux4_1
XTAP_1291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5690_ _2868_ _2859_ VGND VGND VPWR VPWR _2869_ sky130_fd_sc_hd__and2_1
X_4641_ _2290_ _2291_ _1848_ VGND VGND VPWR VPWR _2292_ sky130_fd_sc_hd__mux2_1
X_4572_ memory\[12\]\[19\] memory\[13\]\[19\] memory\[14\]\[19\] memory\[15\]\[19\]
+ _1973_ _1974_ VGND VGND VPWR VPWR _2227_ sky130_fd_sc_hd__mux4_1
X_7360_ clknet_leaf_92_clk _0919_ VGND VGND VPWR VPWR memory\[18\]\[17\] sky130_fd_sc_hd__dfxtp_1
X_6311_ _2899_ _3210_ VGND VGND VPWR VPWR _3220_ sky130_fd_sc_hd__and2_1
Xhold715 memory\[23\]\[23\] VGND VGND VPWR VPWR net924 sky130_fd_sc_hd__dlygate4sd3_1
Xhold704 memory\[8\]\[3\] VGND VGND VPWR VPWR net913 sky130_fd_sc_hd__dlygate4sd3_1
X_7291_ clknet_leaf_73_clk _0850_ VGND VGND VPWR VPWR memory\[8\]\[12\] sky130_fd_sc_hd__dfxtp_1
Xhold737 memory\[31\]\[13\] VGND VGND VPWR VPWR net946 sky130_fd_sc_hd__dlygate4sd3_1
Xhold726 memory\[1\]\[2\] VGND VGND VPWR VPWR net935 sky130_fd_sc_hd__dlygate4sd3_1
X_3523_ _1227_ VGND VGND VPWR VPWR _0011_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_52_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold759 memory\[5\]\[22\] VGND VGND VPWR VPWR net968 sky130_fd_sc_hd__dlygate4sd3_1
Xhold748 memory\[22\]\[30\] VGND VGND VPWR VPWR net957 sky130_fd_sc_hd__dlygate4sd3_1
X_3454_ memory\[20\]\[0\] memory\[21\]\[0\] memory\[22\]\[0\] memory\[23\]\[0\] _1157_
+ _1159_ VGND VGND VPWR VPWR _1160_ sky130_fd_sc_hd__mux4_1
X_6242_ _2905_ _3139_ VGND VGND VPWR VPWR _3180_ sky130_fd_sc_hd__and2_1
XFILLER_0_110_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6173_ net647 _3130_ _3138_ _3141_ VGND VGND VPWR VPWR _1126_ sky130_fd_sc_hd__a31o_1
X_5124_ _2627_ _2609_ VGND VGND VPWR VPWR _2628_ sky130_fd_sc_hd__and2_1
Xclkbuf_leaf_49_clk clknet_4_14_0_clk VGND VGND VPWR VPWR clknet_leaf_49_clk sky130_fd_sc_hd__clkbuf_16
X_5055_ memory\[6\]\[18\] _2572_ _2573_ VGND VGND VPWR VPWR _2582_ sky130_fd_sc_hd__and3_1
X_4006_ _1685_ _1686_ _1521_ VGND VGND VPWR VPWR _1687_ sky130_fd_sc_hd__mux2_1
XFILLER_0_27_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_94_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5957_ net858 _3006_ _3008_ _3016_ VGND VGND VPWR VPWR _1035_ sky130_fd_sc_hd__a31o_1
X_4908_ _2473_ _2497_ _2498_ net699 VGND VGND VPWR VPWR _0503_ sky130_fd_sc_hd__a22o_1
XFILLER_0_118_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_117_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7627_ clknet_leaf_28_clk _0161_ VGND VGND VPWR VPWR memory\[27\]\[28\] sky130_fd_sc_hd__dfxtp_1
X_5888_ _2855_ _2965_ VGND VGND VPWR VPWR _2976_ sky130_fd_sc_hd__and2_1
XFILLER_0_47_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_117_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4839_ _2467_ _2464_ _2465_ net364 VGND VGND VPWR VPWR _0465_ sky130_fd_sc_hd__a22o_1
X_7558_ clknet_leaf_40_clk _1117_ VGND VGND VPWR VPWR memory\[20\]\[23\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_50_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6509_ _2903_ _3281_ VGND VGND VPWR VPWR _3320_ sky130_fd_sc_hd__and2_1
XFILLER_0_30_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7489_ clknet_leaf_99_clk _1048_ VGND VGND VPWR VPWR memory\[24\]\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_101_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold20 memory\[3\]\[24\] VGND VGND VPWR VPWR net229 sky130_fd_sc_hd__dlygate4sd3_1
Xhold31 memory\[16\]\[29\] VGND VGND VPWR VPWR net240 sky130_fd_sc_hd__dlygate4sd3_1
Xhold64 memory\[30\]\[29\] VGND VGND VPWR VPWR net273 sky130_fd_sc_hd__dlygate4sd3_1
Xhold53 memory\[15\]\[10\] VGND VGND VPWR VPWR net262 sky130_fd_sc_hd__dlygate4sd3_1
Xhold42 memory\[2\]\[19\] VGND VGND VPWR VPWR net251 sky130_fd_sc_hd__dlygate4sd3_1
Xhold97 memory\[17\]\[29\] VGND VGND VPWR VPWR net306 sky130_fd_sc_hd__dlygate4sd3_1
Xhold75 memory\[24\]\[13\] VGND VGND VPWR VPWR net284 sky130_fd_sc_hd__dlygate4sd3_1
Xhold86 memory\[30\]\[18\] VGND VGND VPWR VPWR net295 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_58_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_22_622 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XANTENNA_6 _1176_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_22_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6791_ _3439_ VGND VGND VPWR VPWR _3440_ sky130_fd_sc_hd__clkbuf_4
X_5811_ _2461_ _2919_ _2931_ VGND VGND VPWR VPWR _0942_ sky130_fd_sc_hd__a21o_1
X_5742_ net411 _2890_ _2832_ _2904_ VGND VGND VPWR VPWR _0900_ sky130_fd_sc_hd__a31o_1
XFILLER_0_57_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_703 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_29_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_72_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5673_ net806 _2844_ _2833_ _2856_ VGND VGND VPWR VPWR _0879_ sky130_fd_sc_hd__a31o_1
X_4624_ _2086_ _2271_ _2273_ _2275_ _2223_ VGND VGND VPWR VPWR _2276_ sky130_fd_sc_hd__a221o_1
XFILLER_0_60_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7412_ clknet_leaf_108_clk net140 VGND VGND VPWR VPWR memory\[0\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_32_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4555_ _2101_ _2210_ VGND VGND VPWR VPWR _2211_ sky130_fd_sc_hd__or2_1
XFILLER_0_4_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7343_ clknet_leaf_0_clk _0902_ VGND VGND VPWR VPWR memory\[18\]\[0\] sky130_fd_sc_hd__dfxtp_1
Xhold501 memory\[2\]\[0\] VGND VGND VPWR VPWR net710 sky130_fd_sc_hd__dlygate4sd3_1
Xhold545 memory\[30\]\[31\] VGND VGND VPWR VPWR net754 sky130_fd_sc_hd__dlygate4sd3_1
Xhold512 memory\[9\]\[14\] VGND VGND VPWR VPWR net721 sky130_fd_sc_hd__dlygate4sd3_1
X_3506_ memory\[20\]\[1\] memory\[21\]\[1\] memory\[22\]\[1\] memory\[23\]\[1\] _1157_
+ _1159_ VGND VGND VPWR VPWR _1211_ sky130_fd_sc_hd__mux4_1
XFILLER_0_4_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold523 memory\[16\]\[2\] VGND VGND VPWR VPWR net732 sky130_fd_sc_hd__dlygate4sd3_1
Xhold534 memory\[9\]\[8\] VGND VGND VPWR VPWR net743 sky130_fd_sc_hd__dlygate4sd3_1
Xhold556 memory\[28\]\[27\] VGND VGND VPWR VPWR net765 sky130_fd_sc_hd__dlygate4sd3_1
X_7274_ net177 _0019_ VGND VGND VPWR VPWR net101 sky130_fd_sc_hd__dfxtp_2
XFILLER_0_12_165 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold578 memory\[22\]\[7\] VGND VGND VPWR VPWR net787 sky130_fd_sc_hd__dlygate4sd3_1
X_4486_ _2137_ _2145_ VGND VGND VPWR VPWR _2146_ sky130_fd_sc_hd__and2_1
Xhold567 memory\[9\]\[10\] VGND VGND VPWR VPWR net776 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_110_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold589 memory\[22\]\[27\] VGND VGND VPWR VPWR net798 sky130_fd_sc_hd__dlygate4sd3_1
X_6225_ _2888_ _3167_ VGND VGND VPWR VPWR _3171_ sky130_fd_sc_hd__and2_1
X_6156_ _2895_ _3123_ VGND VGND VPWR VPWR _3131_ sky130_fd_sc_hd__and2_1
XTAP_850 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_861 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5107_ net714 _2601_ _2606_ _2616_ VGND VGND VPWR VPWR _0585_ sky130_fd_sc_hd__a31o_1
XTAP_872 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_883 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_894 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6087_ net753 _3088_ _3078_ _3090_ VGND VGND VPWR VPWR _1091_ sky130_fd_sc_hd__a31o_1
X_5038_ _2559_ VGND VGND VPWR VPWR _2573_ sky130_fd_sc_hd__buf_2
XFILLER_0_67_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6989_ clknet_leaf_44_clk _0580_ VGND VGND VPWR VPWR memory\[6\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_63_511 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_36_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_118_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_106_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_120_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput65 net65 VGND VGND VPWR VPWR data_out1[23] sky130_fd_sc_hd__clkbuf_4
Xoutput54 net54 VGND VGND VPWR VPWR data_out1[13] sky130_fd_sc_hd__buf_2
Xoutput76 net76 VGND VGND VPWR VPWR data_out1[4] sky130_fd_sc_hd__clkbuf_4
Xoutput98 net98 VGND VGND VPWR VPWR data_out2[24] sky130_fd_sc_hd__clkbuf_4
Xoutput87 net87 VGND VGND VPWR VPWR data_out2[14] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_85_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_703 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_717 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4340_ memory\[24\]\[8\] memory\[25\]\[8\] memory\[26\]\[8\] memory\[27\]\[8\] _1872_
+ _1873_ VGND VGND VPWR VPWR _2006_ sky130_fd_sc_hd__mux4_1
XFILLER_0_10_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4271_ memory\[20\]\[5\] memory\[21\]\[5\] memory\[22\]\[5\] memory\[23\]\[5\] _1938_
+ _1939_ VGND VGND VPWR VPWR _1940_ sky130_fd_sc_hd__mux4_1
XFILLER_0_120_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6010_ _2901_ _3036_ VGND VGND VPWR VPWR _3046_ sky130_fd_sc_hd__and2_1
XFILLER_0_94_13 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_94_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6912_ clknet_leaf_71_clk _0503_ VGND VGND VPWR VPWR memory\[15\]\[18\] sky130_fd_sc_hd__dfxtp_1
X_7892_ clknet_leaf_116_clk _0426_ VGND VGND VPWR VPWR memory\[17\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_119_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3986_ memory\[8\]\[24\] memory\[9\]\[24\] memory\[10\]\[24\] memory\[11\]\[24\]
+ _1202_ _1203_ VGND VGND VPWR VPWR _1668_ sky130_fd_sc_hd__mux4_1
X_6774_ _3430_ VGND VGND VPWR VPWR _3435_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_91_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5725_ net33 VGND VGND VPWR VPWR _2893_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_72_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5656_ net42 VGND VGND VPWR VPWR _2845_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_115_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4607_ memory\[4\]\[21\] memory\[5\]\[21\] memory\[6\]\[21\] memory\[7\]\[21\] _2014_
+ _2015_ VGND VGND VPWR VPWR _2260_ sky130_fd_sc_hd__mux4_1
XFILLER_0_60_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold320 memory\[9\]\[20\] VGND VGND VPWR VPWR net529 sky130_fd_sc_hd__dlygate4sd3_1
X_5587_ net1055 _2798_ _2789_ _2802_ VGND VGND VPWR VPWR _0847_ sky130_fd_sc_hd__a31o_1
XFILLER_0_5_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_32_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold342 memory\[31\]\[28\] VGND VGND VPWR VPWR net551 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_102_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4538_ memory\[12\]\[17\] memory\[13\]\[17\] memory\[14\]\[17\] memory\[15\]\[17\]
+ _2045_ _2046_ VGND VGND VPWR VPWR _2195_ sky130_fd_sc_hd__mux4_1
Xhold353 memory\[3\]\[5\] VGND VGND VPWR VPWR net562 sky130_fd_sc_hd__dlygate4sd3_1
Xhold331 memory\[28\]\[14\] VGND VGND VPWR VPWR net540 sky130_fd_sc_hd__dlygate4sd3_1
X_7326_ clknet_leaf_83_clk _0885_ VGND VGND VPWR VPWR memory\[7\]\[15\] sky130_fd_sc_hd__dfxtp_1
Xhold375 memory\[13\]\[21\] VGND VGND VPWR VPWR net584 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_111_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold386 memory\[24\]\[27\] VGND VGND VPWR VPWR net595 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_68_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7257_ net160 _0001_ VGND VGND VPWR VPWR net83 sky130_fd_sc_hd__dfxtp_1
Xhold364 memory\[22\]\[6\] VGND VGND VPWR VPWR net573 sky130_fd_sc_hd__dlygate4sd3_1
X_4469_ _2129_ VGND VGND VPWR VPWR _0036_ sky130_fd_sc_hd__clkbuf_1
Xhold397 memory\[23\]\[30\] VGND VGND VPWR VPWR net606 sky130_fd_sc_hd__dlygate4sd3_1
X_6208_ net849 _3159_ _3153_ _3161_ VGND VGND VPWR VPWR _1141_ sky130_fd_sc_hd__a31o_1
X_7188_ clknet_leaf_21_clk _0779_ VGND VGND VPWR VPWR memory\[14\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_6139_ _2878_ _3110_ VGND VGND VPWR VPWR _3121_ sky130_fd_sc_hd__and2_1
XTAP_680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1824 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1802 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1813 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1857 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1846 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1835 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_83_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1868 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_118_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_106_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_121_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_86_400 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_59_647 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_59_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3840_ memory\[20\]\[17\] memory\[21\]\[17\] memory\[22\]\[17\] memory\[23\]\[17\]
+ _1509_ _1510_ VGND VGND VPWR VPWR _1529_ sky130_fd_sc_hd__mux4_1
XFILLER_0_27_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3771_ memory\[8\]\[13\] memory\[9\]\[13\] memory\[10\]\[13\] memory\[11\]\[13\]
+ _1426_ _1427_ VGND VGND VPWR VPWR _1464_ sky130_fd_sc_hd__mux4_1
XFILLER_0_109_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5510_ _2648_ _2779_ _2780_ net691 VGND VGND VPWR VPWR _0824_ sky130_fd_sc_hd__a22o_1
XFILLER_0_89_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6490_ _2884_ _3308_ VGND VGND VPWR VPWR _3310_ sky130_fd_sc_hd__and2_1
XFILLER_0_27_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_120_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5441_ _2486_ _2763_ _2764_ net602 VGND VGND VPWR VPWR _0771_ sky130_fd_sc_hd__a22o_1
X_5372_ _2458_ _2749_ _2751_ net562 VGND VGND VPWR VPWR _0715_ sky130_fd_sc_hd__a22o_1
X_7111_ clknet_leaf_37_clk _0702_ VGND VGND VPWR VPWR memory\[29\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_1_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4323_ _1959_ _1989_ VGND VGND VPWR VPWR _1990_ sky130_fd_sc_hd__or2_1
XFILLER_0_10_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7042_ clknet_leaf_86_clk _0633_ VGND VGND VPWR VPWR memory\[16\]\[19\] sky130_fd_sc_hd__dfxtp_1
X_4254_ memory\[24\]\[4\] memory\[25\]\[4\] memory\[26\]\[4\] memory\[27\]\[4\] _1814_
+ _1816_ VGND VGND VPWR VPWR _1924_ sky130_fd_sc_hd__mux4_1
XFILLER_0_38_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4185_ _1812_ _1857_ VGND VGND VPWR VPWR _1858_ sky130_fd_sc_hd__or2_1
X_7944_ net207 _0049_ VGND VGND VPWR VPWR net67 sky130_fd_sc_hd__dfxtp_2
XTAP_1109 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7875_ clknet_leaf_59_clk _0409_ VGND VGND VPWR VPWR memory\[13\]\[20\] sky130_fd_sc_hd__dfxtp_1
X_6826_ _2676_ _3437_ _3439_ net333 VGND VGND VPWR VPWR _0451_ sky130_fd_sc_hd__a22o_1
XFILLER_0_77_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_80_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6757_ _2621_ _3429_ _3431_ net878 VGND VGND VPWR VPWR _0395_ sky130_fd_sc_hd__a22o_1
X_3969_ memory\[0\]\[23\] memory\[1\]\[23\] memory\[2\]\[23\] memory\[3\]\[23\] _1237_
+ _1238_ VGND VGND VPWR VPWR _1652_ sky130_fd_sc_hd__mux4_1
X_5708_ net28 VGND VGND VPWR VPWR _2881_ sky130_fd_sc_hd__buf_4
XFILLER_0_33_525 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_45_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6688_ net745 _3393_ _3386_ _3395_ VGND VGND VPWR VPWR _0362_ sky130_fd_sc_hd__a31o_1
X_5639_ _2831_ _2558_ VGND VGND VPWR VPWR _2832_ sky130_fd_sc_hd__nand2_4
XFILLER_0_60_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_21_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_13_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold161 memory\[15\]\[28\] VGND VGND VPWR VPWR net370 sky130_fd_sc_hd__dlygate4sd3_1
X_7309_ clknet_leaf_50_clk _0868_ VGND VGND VPWR VPWR memory\[8\]\[30\] sky130_fd_sc_hd__dfxtp_1
Xhold150 memory\[17\]\[0\] VGND VGND VPWR VPWR net359 sky130_fd_sc_hd__dlygate4sd3_1
Xhold172 memory\[31\]\[24\] VGND VGND VPWR VPWR net381 sky130_fd_sc_hd__dlygate4sd3_1
Xhold183 memory\[11\]\[30\] VGND VGND VPWR VPWR net392 sky130_fd_sc_hd__dlygate4sd3_1
Xhold194 memory\[7\]\[10\] VGND VGND VPWR VPWR net403 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_1632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_99_591 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5990_ _3007_ VGND VGND VPWR VPWR _3035_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_86_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4941_ _2508_ VGND VGND VPWR VPWR _2516_ sky130_fd_sc_hd__clkbuf_4
X_4872_ net36 VGND VGND VPWR VPWR _2485_ sky130_fd_sc_hd__buf_4
X_7660_ clknet_leaf_33_clk _0194_ VGND VGND VPWR VPWR memory\[19\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_74_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3823_ _1511_ _1512_ _1472_ VGND VGND VPWR VPWR _1513_ sky130_fd_sc_hd__mux2_1
X_6611_ _2642_ _3371_ _3372_ net484 VGND VGND VPWR VPWR _0308_ sky130_fd_sc_hd__a22o_1
XFILLER_0_24_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7591_ clknet_leaf_27_clk _1150_ VGND VGND VPWR VPWR memory\[23\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_61_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6542_ net1069 _3333_ _3338_ _3340_ VGND VGND VPWR VPWR _0271_ sky130_fd_sc_hd__a31o_1
XFILLER_0_15_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3754_ memory\[4\]\[12\] memory\[5\]\[12\] memory\[6\]\[12\] memory\[7\]\[12\] _1199_
+ _1200_ VGND VGND VPWR VPWR _1448_ sky130_fd_sc_hd__mux4_1
XFILLER_0_54_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3685_ _1186_ _1381_ VGND VGND VPWR VPWR _1382_ sky130_fd_sc_hd__or2_1
X_6473_ _2868_ _3295_ VGND VGND VPWR VPWR _3300_ sky130_fd_sc_hd__and2_1
XFILLER_0_54_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_112_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5424_ _2469_ _2761_ _2762_ net344 VGND VGND VPWR VPWR _0756_ sky130_fd_sc_hd__a22o_1
XFILLER_0_2_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_276 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_11_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5355_ _2483_ _2744_ _2745_ net282 VGND VGND VPWR VPWR _0704_ sky130_fd_sc_hd__a22o_1
XFILLER_0_57_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5286_ _2600_ VGND VGND VPWR VPWR _2717_ sky130_fd_sc_hd__buf_4
X_4306_ _1832_ VGND VGND VPWR VPWR _1974_ sky130_fd_sc_hd__buf_6
X_7025_ clknet_leaf_2_clk _0616_ VGND VGND VPWR VPWR memory\[16\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_4237_ _1820_ _1907_ _1824_ VGND VGND VPWR VPWR _1908_ sky130_fd_sc_hd__o21a_1
X_4168_ _1799_ VGND VGND VPWR VPWR _1842_ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_65_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_528 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4099_ memory\[0\]\[30\] memory\[1\]\[30\] memory\[2\]\[30\] memory\[3\]\[30\] _1271_
+ _1272_ VGND VGND VPWR VPWR _1775_ sky130_fd_sc_hd__mux4_1
X_7927_ net190 _0062_ VGND VGND VPWR VPWR net80 sky130_fd_sc_hd__dfxtp_2
X_7858_ clknet_leaf_22_clk _0392_ VGND VGND VPWR VPWR memory\[13\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_77_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6809_ _2642_ _3441_ _3442_ net285 VGND VGND VPWR VPWR _0436_ sky130_fd_sc_hd__a22o_1
X_7789_ clknet_leaf_25_clk _0323_ VGND VGND VPWR VPWR memory\[30\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_92_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_119 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_60_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_1451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold908 memory\[25\]\[29\] VGND VGND VPWR VPWR net1117 sky130_fd_sc_hd__dlygate4sd3_1
Xhold919 memory\[10\]\[6\] VGND VGND VPWR VPWR net1128 sky130_fd_sc_hd__dlygate4sd3_1
X_3470_ _1165_ VGND VGND VPWR VPWR _1176_ sky130_fd_sc_hd__buf_8
XFILLER_0_10_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_51_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_110_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5140_ net1079 _2629_ _2630_ _2639_ VGND VGND VPWR VPWR _0595_ sky130_fd_sc_hd__a31o_1
X_5071_ _2481_ _2584_ _2591_ VGND VGND VPWR VPWR _0574_ sky130_fd_sc_hd__a21o_1
X_4022_ memory\[4\]\[26\] memory\[5\]\[26\] memory\[6\]\[26\] memory\[7\]\[26\] _1170_
+ _1172_ VGND VGND VPWR VPWR _1702_ sky130_fd_sc_hd__mux4_1
X_5973_ _2863_ _3023_ VGND VGND VPWR VPWR _3026_ sky130_fd_sc_hd__and2_1
X_4924_ net11 net12 VGND VGND VPWR VPWR _2501_ sky130_fd_sc_hd__nor2b_4
XFILLER_0_59_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7712_ clknet_leaf_84_clk _0246_ VGND VGND VPWR VPWR memory\[5\]\[17\] sky130_fd_sc_hd__dfxtp_1
X_4855_ _2448_ VGND VGND VPWR VPWR _2476_ sky130_fd_sc_hd__clkbuf_4
X_7643_ clknet_leaf_88_clk _0177_ VGND VGND VPWR VPWR memory\[19\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_117_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_288 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4786_ _1798_ _2424_ _2426_ _2428_ VGND VGND VPWR VPWR _2429_ sky130_fd_sc_hd__a22o_1
X_7574_ clknet_leaf_111_clk _1133_ VGND VGND VPWR VPWR memory\[23\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_3806_ memory\[28\]\[15\] memory\[29\]\[15\] memory\[30\]\[15\] memory\[31\]\[15\]
+ _1398_ _1399_ VGND VGND VPWR VPWR _1497_ sky130_fd_sc_hd__mux4_1
XFILLER_0_28_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3737_ memory\[12\]\[11\] memory\[13\]\[11\] memory\[14\]\[11\] memory\[15\]\[11\]
+ _1430_ _1431_ VGND VGND VPWR VPWR _1432_ sky130_fd_sc_hd__mux4_2
X_6525_ net400 _3317_ _3324_ _3330_ VGND VGND VPWR VPWR _0264_ sky130_fd_sc_hd__a31o_1
XFILLER_0_15_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6456_ _2851_ _3282_ VGND VGND VPWR VPWR _3290_ sky130_fd_sc_hd__and2_1
X_3668_ _1362_ _1365_ _1243_ VGND VGND VPWR VPWR _1366_ sky130_fd_sc_hd__mux2_1
XFILLER_0_101_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6387_ _3235_ VGND VGND VPWR VPWR _3250_ sky130_fd_sc_hd__clkbuf_4
X_3599_ memory\[28\]\[5\] memory\[29\]\[5\] memory\[30\]\[5\] memory\[31\]\[5\] _1178_
+ _1179_ VGND VGND VPWR VPWR _1300_ sky130_fd_sc_hd__mux4_1
X_5407_ _2759_ VGND VGND VPWR VPWR _2760_ sky130_fd_sc_hd__clkbuf_4
X_5338_ _2466_ _2742_ _2743_ net345 VGND VGND VPWR VPWR _0689_ sky130_fd_sc_hd__a22o_1
X_7008_ clknet_leaf_98_clk _0599_ VGND VGND VPWR VPWR memory\[26\]\[17\] sky130_fd_sc_hd__dfxtp_1
X_5269_ _2694_ VGND VGND VPWR VPWR _2708_ sky130_fd_sc_hd__buf_2
XFILLER_0_92_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_108_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_266 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_65_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4640_ memory\[16\]\[23\] memory\[17\]\[23\] memory\[18\]\[23\] memory\[19\]\[23\]
+ _1970_ _1971_ VGND VGND VPWR VPWR _2291_ sky130_fd_sc_hd__mux4_1
XFILLER_0_115_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_25_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_491 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_114_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6310_ net788 _3213_ _3209_ _3219_ VGND VGND VPWR VPWR _0160_ sky130_fd_sc_hd__a31o_1
X_4571_ _1811_ _2225_ VGND VGND VPWR VPWR _2226_ sky130_fd_sc_hd__or2_1
XFILLER_0_71_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_97_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7290_ clknet_leaf_45_clk _0849_ VGND VGND VPWR VPWR memory\[8\]\[11\] sky130_fd_sc_hd__dfxtp_1
Xhold705 memory\[15\]\[16\] VGND VGND VPWR VPWR net914 sky130_fd_sc_hd__dlygate4sd3_1
Xhold716 memory\[13\]\[4\] VGND VGND VPWR VPWR net925 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold727 memory\[5\]\[14\] VGND VGND VPWR VPWR net936 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3522_ _1218_ _1226_ VGND VGND VPWR VPWR _1227_ sky130_fd_sc_hd__and2_1
XFILLER_0_52_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_122_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_110_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_110_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_97_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6241_ net606 _3172_ _3137_ _3179_ VGND VGND VPWR VPWR _0131_ sky130_fd_sc_hd__a31o_1
XFILLER_0_12_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3453_ _1158_ VGND VGND VPWR VPWR _1159_ sky130_fd_sc_hd__clkbuf_8
Xhold749 memory\[27\]\[12\] VGND VGND VPWR VPWR net958 sky130_fd_sc_hd__dlygate4sd3_1
Xhold738 memory\[30\]\[2\] VGND VGND VPWR VPWR net947 sky130_fd_sc_hd__dlygate4sd3_1
X_6172_ _2834_ _3140_ VGND VGND VPWR VPWR _3141_ sky130_fd_sc_hd__and2_1
X_5123_ net47 VGND VGND VPWR VPWR _2627_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_20_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5054_ _2472_ _2571_ _2581_ VGND VGND VPWR VPWR _0567_ sky130_fd_sc_hd__a21o_1
X_4005_ memory\[0\]\[25\] memory\[1\]\[25\] memory\[2\]\[25\] memory\[3\]\[25\] _1237_
+ _1238_ VGND VGND VPWR VPWR _1686_ sky130_fd_sc_hd__mux4_1
XFILLER_0_79_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5956_ _2847_ _3010_ VGND VGND VPWR VPWR _3016_ sky130_fd_sc_hd__and2_1
XFILLER_0_118_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4907_ _2472_ _2497_ _2498_ net620 VGND VGND VPWR VPWR _0502_ sky130_fd_sc_hd__a22o_1
X_5887_ net315 _2968_ _2963_ _2975_ VGND VGND VPWR VPWR _1006_ sky130_fd_sc_hd__a31o_1
X_7626_ clknet_leaf_29_clk _0160_ VGND VGND VPWR VPWR memory\[27\]\[27\] sky130_fd_sc_hd__dfxtp_1
X_4838_ net19 VGND VGND VPWR VPWR _2467_ sky130_fd_sc_hd__buf_4
X_7557_ clknet_leaf_33_clk _1116_ VGND VGND VPWR VPWR memory\[20\]\[22\] sky130_fd_sc_hd__dfxtp_1
X_4769_ memory\[4\]\[30\] memory\[5\]\[30\] memory\[6\]\[30\] memory\[7\]\[30\] _1813_
+ _1815_ VGND VGND VPWR VPWR _2413_ sky130_fd_sc_hd__mux4_1
XFILLER_0_15_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6508_ net1087 _3317_ _3307_ _3319_ VGND VGND VPWR VPWR _0258_ sky130_fd_sc_hd__a31o_1
X_7488_ clknet_leaf_96_clk _1047_ VGND VGND VPWR VPWR memory\[24\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_30_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6439_ _3279_ VGND VGND VPWR VPWR _3280_ sky130_fd_sc_hd__clkbuf_4
Xhold32 memory\[18\]\[12\] VGND VGND VPWR VPWR net241 sky130_fd_sc_hd__dlygate4sd3_1
Xhold21 memory\[29\]\[0\] VGND VGND VPWR VPWR net230 sky130_fd_sc_hd__dlygate4sd3_1
Xhold10 memory\[29\]\[1\] VGND VGND VPWR VPWR net219 sky130_fd_sc_hd__dlygate4sd3_1
Xhold43 memory\[14\]\[25\] VGND VGND VPWR VPWR net252 sky130_fd_sc_hd__dlygate4sd3_1
Xhold65 memory\[29\]\[21\] VGND VGND VPWR VPWR net274 sky130_fd_sc_hd__dlygate4sd3_1
Xhold54 memory\[3\]\[23\] VGND VGND VPWR VPWR net263 sky130_fd_sc_hd__dlygate4sd3_1
Xhold98 memory\[2\]\[24\] VGND VGND VPWR VPWR net307 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_98_623 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold87 memory\[17\]\[8\] VGND VGND VPWR VPWR net296 sky130_fd_sc_hd__dlygate4sd3_1
Xhold76 memory\[17\]\[15\] VGND VGND VPWR VPWR net285 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_98_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_1_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_21_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_7 _1183_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_104_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_89_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_317 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_49_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_119_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6790_ _2450_ _3437_ VGND VGND VPWR VPWR _3439_ sky130_fd_sc_hd__nor2_4
XFILLER_0_29_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5810_ net1134 _2930_ _2921_ VGND VGND VPWR VPWR _2931_ sky130_fd_sc_hd__and3_1
X_5741_ _2903_ _2835_ VGND VGND VPWR VPWR _2904_ sky130_fd_sc_hd__and2_1
XFILLER_0_32_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_715 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5672_ _2855_ _2836_ VGND VGND VPWR VPWR _2856_ sky130_fd_sc_hd__and2_1
XFILLER_0_32_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7411_ clknet_leaf_10_clk net141 VGND VGND VPWR VPWR memory\[0\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_115_658 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4623_ _2116_ _2274_ _2118_ VGND VGND VPWR VPWR _2275_ sky130_fd_sc_hd__o21a_1
Xhold502 memory\[2\]\[28\] VGND VGND VPWR VPWR net711 sky130_fd_sc_hd__dlygate4sd3_1
X_7342_ clknet_leaf_45_clk _0901_ VGND VGND VPWR VPWR memory\[7\]\[31\] sky130_fd_sc_hd__dfxtp_1
X_4554_ memory\[8\]\[18\] memory\[9\]\[18\] memory\[10\]\[18\] memory\[11\]\[18\]
+ _1913_ _1914_ VGND VGND VPWR VPWR _2210_ sky130_fd_sc_hd__mux4_1
XFILLER_0_4_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7273_ net176 _0018_ VGND VGND VPWR VPWR net100 sky130_fd_sc_hd__dfxtp_2
XFILLER_0_12_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold524 memory\[22\]\[8\] VGND VGND VPWR VPWR net733 sky130_fd_sc_hd__dlygate4sd3_1
Xhold535 memory\[23\]\[6\] VGND VGND VPWR VPWR net744 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_4_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold513 memory\[21\]\[2\] VGND VGND VPWR VPWR net722 sky130_fd_sc_hd__dlygate4sd3_1
X_3505_ _1210_ VGND VGND VPWR VPWR _0000_ sky130_fd_sc_hd__clkbuf_1
Xhold546 memory\[31\]\[22\] VGND VGND VPWR VPWR net755 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_110_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold579 memory\[27\]\[27\] VGND VGND VPWR VPWR net788 sky130_fd_sc_hd__dlygate4sd3_1
Xhold557 memory\[27\]\[25\] VGND VGND VPWR VPWR net766 sky130_fd_sc_hd__dlygate4sd3_1
X_6224_ net643 _3159_ _3166_ _3170_ VGND VGND VPWR VPWR _1148_ sky130_fd_sc_hd__a31o_1
XFILLER_0_12_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold568 memory\[1\]\[3\] VGND VGND VPWR VPWR net777 sky130_fd_sc_hd__dlygate4sd3_1
X_4485_ _2097_ _2140_ _2142_ _2144_ _2066_ VGND VGND VPWR VPWR _2145_ sky130_fd_sc_hd__a221o_1
XFILLER_0_0_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6155_ _3005_ VGND VGND VPWR VPWR _3130_ sky130_fd_sc_hd__buf_4
XTAP_840 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_851 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_862 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6086_ _2901_ _3079_ VGND VGND VPWR VPWR _3090_ sky130_fd_sc_hd__and2_1
X_5106_ _2615_ _2609_ VGND VGND VPWR VPWR _2616_ sky130_fd_sc_hd__and2_1
XTAP_873 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_884 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_895 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5037_ _2529_ VGND VGND VPWR VPWR _2572_ sky130_fd_sc_hd__buf_2
XFILLER_0_95_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_95_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6988_ clknet_leaf_48_clk _0579_ VGND VGND VPWR VPWR memory\[6\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_82_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5939_ net730 _2994_ _2962_ _3004_ VGND VGND VPWR VPWR _1029_ sky130_fd_sc_hd__a31o_1
XFILLER_0_63_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_118_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7609_ clknet_leaf_96_clk _0143_ VGND VGND VPWR VPWR memory\[27\]\[10\] sky130_fd_sc_hd__dfxtp_1
Xclkbuf_4_10_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_10_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_101_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput66 net66 VGND VGND VPWR VPWR data_out1[24] sky130_fd_sc_hd__clkbuf_4
Xoutput55 net55 VGND VGND VPWR VPWR data_out1[14] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_9_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput99 net99 VGND VGND VPWR VPWR data_out2[25] sky130_fd_sc_hd__clkbuf_4
Xoutput88 net88 VGND VGND VPWR VPWR data_out2[15] sky130_fd_sc_hd__clkbuf_4
Xoutput77 net77 VGND VGND VPWR VPWR data_out1[5] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_98_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_98_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_78_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_34_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4270_ _1801_ VGND VGND VPWR VPWR _1939_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_94_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6911_ clknet_leaf_67_clk _0502_ VGND VGND VPWR VPWR memory\[15\]\[17\] sky130_fd_sc_hd__dfxtp_1
X_7891_ clknet_leaf_1_clk _0425_ VGND VGND VPWR VPWR memory\[17\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_49_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3985_ _1584_ _1662_ _1664_ _1666_ _1597_ VGND VGND VPWR VPWR _1667_ sky130_fd_sc_hd__a221o_1
X_6773_ _3428_ VGND VGND VPWR VPWR _3434_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_9_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5724_ net1007 _2890_ _2880_ _2892_ VGND VGND VPWR VPWR _0894_ sky130_fd_sc_hd__a31o_1
XFILLER_0_17_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5655_ _2730_ VGND VGND VPWR VPWR _2844_ sky130_fd_sc_hd__buf_4
X_4606_ _2086_ _2254_ _2256_ _2258_ _2223_ VGND VGND VPWR VPWR _2259_ sky130_fd_sc_hd__a221o_1
XFILLER_0_87_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_5_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_4_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5586_ _2627_ _2791_ VGND VGND VPWR VPWR _2802_ sky130_fd_sc_hd__and2_1
XFILLER_0_5_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold310 memory\[18\]\[14\] VGND VGND VPWR VPWR net519 sky130_fd_sc_hd__dlygate4sd3_1
X_7325_ clknet_leaf_83_clk _0884_ VGND VGND VPWR VPWR memory\[7\]\[14\] sky130_fd_sc_hd__dfxtp_1
Xhold343 memory\[14\]\[1\] VGND VGND VPWR VPWR net552 sky130_fd_sc_hd__dlygate4sd3_1
X_4537_ _2101_ _2193_ VGND VGND VPWR VPWR _2194_ sky130_fd_sc_hd__or2_1
XFILLER_0_7_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold321 memory\[7\]\[5\] VGND VGND VPWR VPWR net530 sky130_fd_sc_hd__dlygate4sd3_1
Xhold332 memory\[4\]\[13\] VGND VGND VPWR VPWR net541 sky130_fd_sc_hd__dlygate4sd3_1
Xhold365 memory\[9\]\[27\] VGND VGND VPWR VPWR net574 sky130_fd_sc_hd__dlygate4sd3_1
Xhold354 memory\[19\]\[14\] VGND VGND VPWR VPWR net563 sky130_fd_sc_hd__dlygate4sd3_1
Xhold387 memory\[23\]\[8\] VGND VGND VPWR VPWR net596 sky130_fd_sc_hd__dlygate4sd3_1
Xhold376 memory\[29\]\[13\] VGND VGND VPWR VPWR net585 sky130_fd_sc_hd__dlygate4sd3_1
X_4468_ _2120_ _2128_ VGND VGND VPWR VPWR _2129_ sky130_fd_sc_hd__and2_1
X_7256_ net159 _0031_ VGND VGND VPWR VPWR net113 sky130_fd_sc_hd__dfxtp_1
X_7187_ clknet_leaf_22_clk _0778_ VGND VGND VPWR VPWR memory\[14\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_6207_ _2870_ _3154_ VGND VGND VPWR VPWR _3161_ sky130_fd_sc_hd__and2_1
Xhold398 memory\[30\]\[14\] VGND VGND VPWR VPWR net607 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_110_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6138_ net863 _3117_ _3109_ _3120_ VGND VGND VPWR VPWR _1112_ sky130_fd_sc_hd__a31o_1
XTAP_670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4399_ memory\[4\]\[10\] memory\[5\]\[10\] memory\[6\]\[10\] memory\[7\]\[10\] _1842_
+ _1843_ VGND VGND VPWR VPWR _2063_ sky130_fd_sc_hd__mux4_2
XTAP_681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6069_ _2884_ _3079_ VGND VGND VPWR VPWR _3081_ sky130_fd_sc_hd__and2_1
XTAP_1825 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1803 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1814 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1858 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1847 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1836 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1869 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_36_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_90_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_102_661 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_31_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_46_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_139 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_27_534 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3770_ _1461_ _1462_ _1243_ VGND VGND VPWR VPWR _1463_ sky130_fd_sc_hd__mux2_1
X_5440_ _2485_ _2763_ _2764_ net711 VGND VGND VPWR VPWR _0770_ sky130_fd_sc_hd__a22o_1
XFILLER_0_2_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_1_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5371_ _2457_ _2749_ _2751_ net1005 VGND VGND VPWR VPWR _0714_ sky130_fd_sc_hd__a22o_1
X_7110_ clknet_leaf_36_clk _0701_ VGND VGND VPWR VPWR memory\[29\]\[23\] sky130_fd_sc_hd__dfxtp_1
X_4322_ memory\[24\]\[7\] memory\[25\]\[7\] memory\[26\]\[7\] memory\[27\]\[7\] _1960_
+ _1961_ VGND VGND VPWR VPWR _1989_ sky130_fd_sc_hd__mux4_1
X_4253_ _1921_ _1922_ _1903_ VGND VGND VPWR VPWR _1923_ sky130_fd_sc_hd__mux2_1
X_7041_ clknet_leaf_91_clk _0632_ VGND VGND VPWR VPWR memory\[16\]\[18\] sky130_fd_sc_hd__dfxtp_1
X_4184_ memory\[24\]\[1\] memory\[25\]\[1\] memory\[26\]\[1\] memory\[27\]\[1\] _1814_
+ _1816_ VGND VGND VPWR VPWR _1857_ sky130_fd_sc_hd__mux4_1
X_7943_ net206 _0048_ VGND VGND VPWR VPWR net66 sky130_fd_sc_hd__dfxtp_2
XFILLER_0_89_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7874_ clknet_leaf_66_clk _0408_ VGND VGND VPWR VPWR memory\[13\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_49_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6825_ _2673_ _3443_ _3444_ net306 VGND VGND VPWR VPWR _0450_ sky130_fd_sc_hd__a22o_1
XFILLER_0_65_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_9_211 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3968_ memory\[4\]\[23\] memory\[5\]\[23\] memory\[6\]\[23\] memory\[7\]\[23\] _1170_
+ _1172_ VGND VGND VPWR VPWR _1651_ sky130_fd_sc_hd__mux4_1
XFILLER_0_70_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6756_ _2619_ _3429_ _3431_ net903 VGND VGND VPWR VPWR _0394_ sky130_fd_sc_hd__a22o_1
X_5707_ _2832_ VGND VGND VPWR VPWR _2880_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_70_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3899_ memory\[20\]\[20\] memory\[21\]\[20\] memory\[22\]\[20\] memory\[23\]\[20\]
+ _1509_ _1510_ VGND VGND VPWR VPWR _1585_ sky130_fd_sc_hd__mux4_1
XFILLER_0_72_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6687_ net43 _3388_ VGND VGND VPWR VPWR _3395_ sky130_fd_sc_hd__and2_1
XFILLER_0_115_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5638_ _2510_ _2490_ VGND VGND VPWR VPWR _2831_ sky130_fd_sc_hd__and2_2
XFILLER_0_72_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5569_ _2611_ _2791_ VGND VGND VPWR VPWR _2793_ sky130_fd_sc_hd__and2_1
X_7308_ clknet_leaf_37_clk _0867_ VGND VGND VPWR VPWR memory\[8\]\[29\] sky130_fd_sc_hd__dfxtp_1
Xhold151 memory\[26\]\[28\] VGND VGND VPWR VPWR net360 sky130_fd_sc_hd__dlygate4sd3_1
Xhold162 memory\[14\]\[17\] VGND VGND VPWR VPWR net371 sky130_fd_sc_hd__dlygate4sd3_1
Xhold140 memory\[28\]\[5\] VGND VGND VPWR VPWR net349 sky130_fd_sc_hd__dlygate4sd3_1
Xhold195 memory\[12\]\[25\] VGND VGND VPWR VPWR net404 sky130_fd_sc_hd__dlygate4sd3_1
Xhold184 memory\[20\]\[28\] VGND VGND VPWR VPWR net393 sky130_fd_sc_hd__dlygate4sd3_1
Xhold173 memory\[22\]\[31\] VGND VGND VPWR VPWR net382 sky130_fd_sc_hd__dlygate4sd3_1
X_7239_ clknet_leaf_37_clk _0830_ VGND VGND VPWR VPWR memory\[31\]\[24\] sky130_fd_sc_hd__dfxtp_1
X_6843__51 clknet_1_1__leaf__3445_ VGND VGND VPWR VPWR net196 sky130_fd_sc_hd__inv_2
XTAP_1600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_122_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_122_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_106_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_121_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_91_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_59_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_115_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4940_ _2454_ _2505_ _2515_ VGND VGND VPWR VPWR _0519_ sky130_fd_sc_hd__a21o_1
X_4871_ _2484_ _2476_ _2477_ net765 VGND VGND VPWR VPWR _0480_ sky130_fd_sc_hd__a22o_1
XFILLER_0_115_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_106 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_7590_ clknet_leaf_18_clk _1149_ VGND VGND VPWR VPWR memory\[23\]\[23\] sky130_fd_sc_hd__dfxtp_1
X_3822_ memory\[16\]\[16\] memory\[17\]\[16\] memory\[18\]\[16\] memory\[19\]\[16\]
+ _1349_ _1350_ VGND VGND VPWR VPWR _1512_ sky130_fd_sc_hd__mux4_1
X_6610_ _2640_ _3371_ _3372_ net607 VGND VGND VPWR VPWR _0307_ sky130_fd_sc_hd__a22o_1
X_6541_ _2858_ _3339_ VGND VGND VPWR VPWR _3340_ sky130_fd_sc_hd__and2_1
X_3753_ _1193_ _1446_ _1197_ VGND VGND VPWR VPWR _1447_ sky130_fd_sc_hd__o21a_1
XFILLER_0_55_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_515 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_40_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3684_ memory\[8\]\[9\] memory\[9\]\[9\] memory\[10\]\[9\] memory\[11\]\[9\] _1202_
+ _1203_ VGND VGND VPWR VPWR _1381_ sky130_fd_sc_hd__mux4_1
X_6472_ net534 _3291_ _3294_ _3299_ VGND VGND VPWR VPWR _0242_ sky130_fd_sc_hd__a31o_1
XFILLER_0_40_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5423_ _2468_ _2761_ _2762_ net670 VGND VGND VPWR VPWR _0755_ sky130_fd_sc_hd__a22o_1
X_5354_ _2482_ _2744_ _2745_ net422 VGND VGND VPWR VPWR _0703_ sky130_fd_sc_hd__a22o_1
XFILLER_0_2_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_112_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4305_ _1830_ VGND VGND VPWR VPWR _1973_ sky130_fd_sc_hd__buf_8
X_5285_ net828 _2704_ _2707_ _2716_ VGND VGND VPWR VPWR _0663_ sky130_fd_sc_hd__a31o_1
XFILLER_0_49_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_7024_ clknet_leaf_112_clk _0615_ VGND VGND VPWR VPWR memory\[16\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_4236_ memory\[28\]\[3\] memory\[29\]\[3\] memory\[30\]\[3\] memory\[31\]\[3\] _1821_
+ _1822_ VGND VGND VPWR VPWR _1907_ sky130_fd_sc_hd__mux4_1
X_4167_ _1836_ _1839_ _1840_ VGND VGND VPWR VPWR _1841_ sky130_fd_sc_hd__o21a_1
XFILLER_0_4_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_78_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4098_ memory\[4\]\[30\] memory\[5\]\[30\] memory\[6\]\[30\] memory\[7\]\[30\] _1161_
+ _1162_ VGND VGND VPWR VPWR _1774_ sky130_fd_sc_hd__mux4_1
X_7926_ net189 _0061_ VGND VGND VPWR VPWR net79 sky130_fd_sc_hd__dfxtp_1
X_7857_ clknet_leaf_6_clk _0391_ VGND VGND VPWR VPWR memory\[13\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_77_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6808_ _2640_ _3441_ _3442_ net638 VGND VGND VPWR VPWR _0435_ sky130_fd_sc_hd__a22o_1
XFILLER_0_18_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7788_ clknet_leaf_31_clk _0322_ VGND VGND VPWR VPWR memory\[30\]\[29\] sky130_fd_sc_hd__dfxtp_1
X_6739_ net783 _2509_ _3413_ _3423_ VGND VGND VPWR VPWR _0385_ sky130_fd_sc_hd__a31o_1
XFILLER_0_18_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_46_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_116_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_104_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_73_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_103_233 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_103_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_114_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold909 memory\[10\]\[27\] VGND VGND VPWR VPWR net1118 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_122_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_122_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_86_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5070_ memory\[6\]\[24\] _2585_ _2586_ VGND VGND VPWR VPWR _2591_ sky130_fd_sc_hd__and3_1
X_4021_ _1584_ _1696_ _1698_ _1700_ _1597_ VGND VGND VPWR VPWR _1701_ sky130_fd_sc_hd__a221o_1
X_5972_ net990 _3021_ _3022_ _3025_ VGND VGND VPWR VPWR _1041_ sky130_fd_sc_hd__a31o_1
X_4923_ _2488_ _2493_ _2495_ net294 VGND VGND VPWR VPWR _0516_ sky130_fd_sc_hd__a22o_1
X_7711_ clknet_leaf_87_clk _0245_ VGND VGND VPWR VPWR memory\[5\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_117_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4854_ net28 VGND VGND VPWR VPWR _2475_ sky130_fd_sc_hd__clkbuf_8
X_7642_ clknet_leaf_89_clk _0176_ VGND VGND VPWR VPWR memory\[19\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_51_40 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4785_ _1820_ _2427_ _1824_ VGND VGND VPWR VPWR _2428_ sky130_fd_sc_hd__o21a_1
XFILLER_0_62_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7573_ clknet_leaf_111_clk _1132_ VGND VGND VPWR VPWR memory\[23\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_3805_ _1394_ _1495_ VGND VGND VPWR VPWR _1496_ sky130_fd_sc_hd__or2_1
XFILLER_0_28_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3736_ _1189_ VGND VGND VPWR VPWR _1431_ sky130_fd_sc_hd__buf_4
X_6524_ _2842_ _3326_ VGND VGND VPWR VPWR _3330_ sky130_fd_sc_hd__and2_1
X_6455_ net773 _3275_ _3280_ _3289_ VGND VGND VPWR VPWR _0235_ sky130_fd_sc_hd__a31o_1
XFILLER_0_42_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3667_ memory\[0\]\[8\] memory\[1\]\[8\] memory\[2\]\[8\] memory\[3\]\[8\] _1363_
+ _1364_ VGND VGND VPWR VPWR _1365_ sky130_fd_sc_hd__mux4_1
X_5406_ _2451_ _2757_ VGND VGND VPWR VPWR _2759_ sky130_fd_sc_hd__nor2_4
X_6386_ _3145_ VGND VGND VPWR VPWR _3249_ sky130_fd_sc_hd__clkbuf_4
X_3598_ _1169_ _1298_ VGND VGND VPWR VPWR _1299_ sky130_fd_sc_hd__or2_1
XFILLER_0_11_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5337_ _2463_ _2742_ _2743_ net329 VGND VGND VPWR VPWR _0688_ sky130_fd_sc_hd__a22o_1
X_5268_ _2692_ VGND VGND VPWR VPWR _2707_ sky130_fd_sc_hd__clkbuf_4
X_7007_ clknet_leaf_89_clk _0598_ VGND VGND VPWR VPWR memory\[26\]\[16\] sky130_fd_sc_hd__dfxtp_1
X_4219_ _1798_ _1886_ _1888_ _1890_ _1827_ VGND VGND VPWR VPWR _1891_ sky130_fd_sc_hd__a221o_1
X_5199_ _2444_ _2445_ VGND VGND VPWR VPWR _2680_ sky130_fd_sc_hd__nor2_1
XFILLER_0_97_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7909_ clknet_leaf_39_clk _0443_ VGND VGND VPWR VPWR memory\[17\]\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_108_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_65_234 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_65_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_34_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_116_380 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_104_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_96_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4570_ memory\[8\]\[19\] memory\[9\]\[19\] memory\[10\]\[19\] memory\[11\]\[19\]
+ _1948_ _1949_ VGND VGND VPWR VPWR _2225_ sky130_fd_sc_hd__mux4_1
XFILLER_0_108_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3521_ _1220_ _1222_ _1225_ _1207_ _1208_ VGND VGND VPWR VPWR _1226_ sky130_fd_sc_hd__a221o_1
Xhold728 memory\[23\]\[26\] VGND VGND VPWR VPWR net937 sky130_fd_sc_hd__dlygate4sd3_1
Xhold717 memory\[17\]\[6\] VGND VGND VPWR VPWR net926 sky130_fd_sc_hd__dlygate4sd3_1
Xhold706 memory\[27\]\[15\] VGND VGND VPWR VPWR net915 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_24_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_122_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_122_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold739 memory\[21\]\[25\] VGND VGND VPWR VPWR net948 sky130_fd_sc_hd__dlygate4sd3_1
X_6240_ _2903_ _3139_ VGND VGND VPWR VPWR _3179_ sky130_fd_sc_hd__and2_1
X_3452_ net7 VGND VGND VPWR VPWR _1158_ sky130_fd_sc_hd__buf_4
X_6171_ _3139_ VGND VGND VPWR VPWR _3140_ sky130_fd_sc_hd__buf_2
XFILLER_0_110_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5122_ net507 _2601_ _2606_ _2626_ VGND VGND VPWR VPWR _0590_ sky130_fd_sc_hd__a31o_1
X_5053_ net1149 _2572_ _2573_ VGND VGND VPWR VPWR _2581_ sky130_fd_sc_hd__and3_1
X_4004_ memory\[4\]\[25\] memory\[5\]\[25\] memory\[6\]\[25\] memory\[7\]\[25\] _1170_
+ _1172_ VGND VGND VPWR VPWR _1685_ sky130_fd_sc_hd__mux4_1
XFILLER_0_79_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5955_ net322 _3006_ _3008_ _3015_ VGND VGND VPWR VPWR _1034_ sky130_fd_sc_hd__a31o_1
XFILLER_0_47_212 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4906_ _2471_ _2497_ _2498_ net914 VGND VGND VPWR VPWR _0501_ sky130_fd_sc_hd__a22o_1
X_5886_ _2853_ _2965_ VGND VGND VPWR VPWR _2975_ sky130_fd_sc_hd__and2_1
XFILLER_0_118_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_7625_ clknet_leaf_30_clk _0159_ VGND VGND VPWR VPWR memory\[27\]\[26\] sky130_fd_sc_hd__dfxtp_1
X_4837_ _2466_ _2464_ _2465_ net269 VGND VGND VPWR VPWR _0464_ sky130_fd_sc_hd__a22o_1
XFILLER_0_16_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7556_ clknet_leaf_40_clk _1115_ VGND VGND VPWR VPWR memory\[20\]\[21\] sky130_fd_sc_hd__dfxtp_1
X_4768_ _1978_ _2407_ _2409_ _2411_ _1826_ VGND VGND VPWR VPWR _2412_ sky130_fd_sc_hd__a221o_1
XFILLER_0_120_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4699_ _2345_ _2346_ _2191_ VGND VGND VPWR VPWR _2347_ sky130_fd_sc_hd__mux2_1
X_6507_ _2901_ _3308_ VGND VGND VPWR VPWR _3319_ sky130_fd_sc_hd__and2_1
X_3719_ _1414_ VGND VGND VPWR VPWR _0001_ sky130_fd_sc_hd__clkbuf_1
X_7487_ clknet_leaf_95_clk _1046_ VGND VGND VPWR VPWR memory\[24\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_113_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6438_ _3278_ VGND VGND VPWR VPWR _3279_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_101_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6369_ net482 _3233_ _3236_ _3240_ VGND VGND VPWR VPWR _0198_ sky130_fd_sc_hd__a31o_1
Xhold11 memory\[17\]\[28\] VGND VGND VPWR VPWR net220 sky130_fd_sc_hd__dlygate4sd3_1
Xhold22 memory\[13\]\[16\] VGND VGND VPWR VPWR net231 sky130_fd_sc_hd__dlygate4sd3_1
Xhold55 memory\[18\]\[11\] VGND VGND VPWR VPWR net264 sky130_fd_sc_hd__dlygate4sd3_1
Xhold33 memory\[2\]\[6\] VGND VGND VPWR VPWR net242 sky130_fd_sc_hd__dlygate4sd3_1
Xhold44 memory\[29\]\[5\] VGND VGND VPWR VPWR net253 sky130_fd_sc_hd__dlygate4sd3_1
Xhold77 memory\[30\]\[23\] VGND VGND VPWR VPWR net286 sky130_fd_sc_hd__dlygate4sd3_1
Xhold88 memory\[16\]\[27\] VGND VGND VPWR VPWR net297 sky130_fd_sc_hd__dlygate4sd3_1
Xhold99 memory\[19\]\[21\] VGND VGND VPWR VPWR net308 sky130_fd_sc_hd__dlygate4sd3_1
Xhold66 memory\[12\]\[19\] VGND VGND VPWR VPWR net275 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_98_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_156 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_66_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_8 _1190_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_104_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_134 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5740_ net39 VGND VGND VPWR VPWR _2903_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_57_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_leaf_108_clk clknet_4_1_0_clk VGND VGND VPWR VPWR clknet_leaf_108_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_8_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1090 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_115_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5671_ net47 VGND VGND VPWR VPWR _2855_ sky130_fd_sc_hd__clkbuf_4
X_7410_ clknet_leaf_106_clk net142 VGND VGND VPWR VPWR memory\[0\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_4622_ memory\[28\]\[22\] memory\[29\]\[22\] memory\[30\]\[22\] memory\[31\]\[22\]
+ _2092_ _2093_ VGND VGND VPWR VPWR _2274_ sky130_fd_sc_hd__mux4_1
XFILLER_0_44_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7341_ clknet_leaf_47_clk _0900_ VGND VGND VPWR VPWR memory\[7\]\[30\] sky130_fd_sc_hd__dfxtp_1
X_4553_ _2207_ _2208_ _2191_ VGND VGND VPWR VPWR _2209_ sky130_fd_sc_hd__mux2_1
Xhold503 memory\[12\]\[18\] VGND VGND VPWR VPWR net712 sky130_fd_sc_hd__dlygate4sd3_1
X_4484_ _2104_ _2143_ _2106_ VGND VGND VPWR VPWR _2144_ sky130_fd_sc_hd__o21a_1
X_7272_ net175 _0017_ VGND VGND VPWR VPWR net99 sky130_fd_sc_hd__dfxtp_2
Xhold525 memory\[26\]\[2\] VGND VGND VPWR VPWR net734 sky130_fd_sc_hd__dlygate4sd3_1
Xhold514 memory\[7\]\[17\] VGND VGND VPWR VPWR net723 sky130_fd_sc_hd__dlygate4sd3_1
X_3504_ _1185_ _1209_ VGND VGND VPWR VPWR _1210_ sky130_fd_sc_hd__and2_1
Xhold536 memory\[9\]\[5\] VGND VGND VPWR VPWR net745 sky130_fd_sc_hd__dlygate4sd3_1
X_6223_ _2886_ _3167_ VGND VGND VPWR VPWR _3170_ sky130_fd_sc_hd__and2_1
Xhold547 memory\[12\]\[12\] VGND VGND VPWR VPWR net756 sky130_fd_sc_hd__dlygate4sd3_1
Xhold558 memory\[22\]\[5\] VGND VGND VPWR VPWR net767 sky130_fd_sc_hd__dlygate4sd3_1
Xhold569 memory\[18\]\[8\] VGND VGND VPWR VPWR net778 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6154_ net619 _3117_ _3122_ _3129_ VGND VGND VPWR VPWR _1119_ sky130_fd_sc_hd__a31o_1
XTAP_830 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_841 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_852 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6085_ net739 _3088_ _3078_ _3089_ VGND VGND VPWR VPWR _1090_ sky130_fd_sc_hd__a31o_1
X_5105_ net41 VGND VGND VPWR VPWR _2615_ sky130_fd_sc_hd__buf_4
XFILLER_0_57_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_874 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_863 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_885 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5036_ _2555_ VGND VGND VPWR VPWR _2571_ sky130_fd_sc_hd__clkbuf_4
XTAP_896 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6987_ clknet_leaf_47_clk _0578_ VGND VGND VPWR VPWR memory\[6\]\[28\] sky130_fd_sc_hd__dfxtp_1
X_5938_ _2905_ _2964_ VGND VGND VPWR VPWR _3004_ sky130_fd_sc_hd__and2_1
XFILLER_0_8_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5869_ _2834_ _2965_ VGND VGND VPWR VPWR _2966_ sky130_fd_sc_hd__and2_1
XFILLER_0_118_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7608_ clknet_leaf_113_clk _0142_ VGND VGND VPWR VPWR memory\[27\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_35_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_398 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_7539_ clknet_leaf_114_clk _1098_ VGND VGND VPWR VPWR memory\[20\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_105_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_71_590 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_101_353 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_101_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput56 net56 VGND VGND VPWR VPWR data_out1[15] sky130_fd_sc_hd__buf_2
Xoutput67 net67 VGND VGND VPWR VPWR data_out1[25] sky130_fd_sc_hd__buf_2
Xoutput78 net78 VGND VGND VPWR VPWR data_out1[6] sky130_fd_sc_hd__clkbuf_4
Xoutput89 net89 VGND VGND VPWR VPWR data_out2[16] sky130_fd_sc_hd__clkbuf_4
XPHY_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_109_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6910_ clknet_leaf_67_clk _0501_ VGND VGND VPWR VPWR memory\[15\]\[16\] sky130_fd_sc_hd__dfxtp_1
X_7890_ clknet_leaf_1_clk _0424_ VGND VGND VPWR VPWR memory\[17\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_76_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3984_ _1591_ _1665_ _1595_ VGND VGND VPWR VPWR _1666_ sky130_fd_sc_hd__o21a_1
X_6772_ _2650_ _3432_ _3433_ net436 VGND VGND VPWR VPWR _0408_ sky130_fd_sc_hd__a22o_1
XFILLER_0_57_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5723_ _2891_ _2882_ VGND VGND VPWR VPWR _2892_ sky130_fd_sc_hd__and2_1
XFILLER_0_72_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5654_ net717 _2824_ _2833_ _2843_ VGND VGND VPWR VPWR _0873_ sky130_fd_sc_hd__a31o_1
X_4605_ _2116_ _2257_ _2118_ VGND VGND VPWR VPWR _2258_ sky130_fd_sc_hd__o21a_1
XFILLER_0_5_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold300 memory\[28\]\[22\] VGND VGND VPWR VPWR net509 sky130_fd_sc_hd__dlygate4sd3_1
Xhold311 memory\[14\]\[18\] VGND VGND VPWR VPWR net520 sky130_fd_sc_hd__dlygate4sd3_1
X_5585_ net536 _2798_ _2789_ _2801_ VGND VGND VPWR VPWR _0846_ sky130_fd_sc_hd__a31o_1
X_7324_ clknet_leaf_87_clk _0883_ VGND VGND VPWR VPWR memory\[7\]\[13\] sky130_fd_sc_hd__dfxtp_1
Xhold344 memory\[14\]\[10\] VGND VGND VPWR VPWR net553 sky130_fd_sc_hd__dlygate4sd3_1
X_4536_ memory\[8\]\[17\] memory\[9\]\[17\] memory\[10\]\[17\] memory\[11\]\[17\]
+ _1913_ _1914_ VGND VGND VPWR VPWR _2193_ sky130_fd_sc_hd__mux4_1
Xhold333 memory\[12\]\[6\] VGND VGND VPWR VPWR net542 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_4_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold322 memory\[3\]\[1\] VGND VGND VPWR VPWR net531 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_111_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold355 memory\[4\]\[26\] VGND VGND VPWR VPWR net564 sky130_fd_sc_hd__dlygate4sd3_1
X_4467_ _2122_ _2124_ _2127_ _1850_ _2066_ VGND VGND VPWR VPWR _2128_ sky130_fd_sc_hd__a221o_1
Xhold377 memory\[23\]\[9\] VGND VGND VPWR VPWR net586 sky130_fd_sc_hd__dlygate4sd3_1
Xhold366 memory\[31\]\[9\] VGND VGND VPWR VPWR net575 sky130_fd_sc_hd__dlygate4sd3_1
X_7255_ net158 _0030_ VGND VGND VPWR VPWR net112 sky130_fd_sc_hd__dfxtp_1
Xhold399 memory\[28\]\[21\] VGND VGND VPWR VPWR net608 sky130_fd_sc_hd__dlygate4sd3_1
X_4398_ _1836_ _2061_ _1840_ VGND VGND VPWR VPWR _2062_ sky130_fd_sc_hd__o21a_1
X_7186_ clknet_leaf_22_clk _0777_ VGND VGND VPWR VPWR memory\[14\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_6206_ net1037 _3159_ _3153_ _3160_ VGND VGND VPWR VPWR _1140_ sky130_fd_sc_hd__a31o_1
Xhold388 memory\[27\]\[3\] VGND VGND VPWR VPWR net597 sky130_fd_sc_hd__dlygate4sd3_1
X_6137_ _2876_ _3110_ VGND VGND VPWR VPWR _3120_ sky130_fd_sc_hd__and2_1
XTAP_660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6068_ net549 _3075_ _3078_ _3080_ VGND VGND VPWR VPWR _1082_ sky130_fd_sc_hd__a31o_1
X_5019_ _2454_ _2556_ _2562_ VGND VGND VPWR VPWR _0551_ sky130_fd_sc_hd__a21o_1
XTAP_1804 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1815 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1848 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1837 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1826 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1859 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_118_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_118_294 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_51_516 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_121_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_54_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_2_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_22_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5370_ _2456_ _2749_ _2751_ net510 VGND VGND VPWR VPWR _0713_ sky130_fd_sc_hd__a22o_1
XFILLER_0_66_9 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4321_ _1988_ VGND VGND VPWR VPWR _0060_ sky130_fd_sc_hd__clkbuf_1
X_6829__38 clknet_1_0__leaf__2787_ VGND VGND VPWR VPWR net183 sky130_fd_sc_hd__inv_2
X_4252_ memory\[16\]\[4\] memory\[17\]\[4\] memory\[18\]\[4\] memory\[19\]\[4\] _1804_
+ _1805_ VGND VGND VPWR VPWR _1922_ sky130_fd_sc_hd__mux4_1
X_7040_ clknet_leaf_90_clk _0631_ VGND VGND VPWR VPWR memory\[16\]\[17\] sky130_fd_sc_hd__dfxtp_1
X_4183_ _1854_ _1855_ _1809_ VGND VGND VPWR VPWR _1856_ sky130_fd_sc_hd__mux2_1
X_7942_ net205 _0047_ VGND VGND VPWR VPWR net65 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_89_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7873_ clknet_leaf_65_clk _0407_ VGND VGND VPWR VPWR memory\[13\]\[18\] sky130_fd_sc_hd__dfxtp_1
X_6824_ _2671_ _3443_ _3444_ net220 VGND VGND VPWR VPWR _0449_ sky130_fd_sc_hd__a22o_1
XFILLER_0_9_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3967_ _1584_ _1645_ _1647_ _1649_ _1597_ VGND VGND VPWR VPWR _1650_ sky130_fd_sc_hd__a221o_1
X_6755_ _2617_ _3429_ _3431_ net925 VGND VGND VPWR VPWR _0393_ sky130_fd_sc_hd__a22o_1
XFILLER_0_70_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5706_ net977 _2867_ _2857_ _2879_ VGND VGND VPWR VPWR _0889_ sky130_fd_sc_hd__a31o_1
Xclkbuf_leaf_30_clk clknet_4_10_0_clk VGND VGND VPWR VPWR clknet_leaf_30_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_115_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3898_ _1154_ VGND VGND VPWR VPWR _1584_ sky130_fd_sc_hd__clkbuf_4
X_6686_ net894 _3393_ _3386_ _3394_ VGND VGND VPWR VPWR _0361_ sky130_fd_sc_hd__a31o_1
X_5637_ net983 _2824_ _2788_ _2830_ VGND VGND VPWR VPWR _0869_ sky130_fd_sc_hd__a31o_1
X_5568_ net940 _2731_ _2789_ _2792_ VGND VGND VPWR VPWR _0838_ sky130_fd_sc_hd__a31o_1
XFILLER_0_60_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold152 memory\[30\]\[21\] VGND VGND VPWR VPWR net361 sky130_fd_sc_hd__dlygate4sd3_1
X_7307_ clknet_leaf_37_clk _0866_ VGND VGND VPWR VPWR memory\[8\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_103_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold130 memory\[9\]\[1\] VGND VGND VPWR VPWR net339 sky130_fd_sc_hd__dlygate4sd3_1
X_4519_ memory\[0\]\[16\] memory\[1\]\[16\] memory\[2\]\[16\] memory\[3\]\[16\] _1845_
+ _1846_ VGND VGND VPWR VPWR _2177_ sky130_fd_sc_hd__mux4_1
Xhold141 memory\[23\]\[16\] VGND VGND VPWR VPWR net350 sky130_fd_sc_hd__dlygate4sd3_1
Xhold174 memory\[14\]\[23\] VGND VGND VPWR VPWR net383 sky130_fd_sc_hd__dlygate4sd3_1
X_7238_ clknet_leaf_35_clk _0829_ VGND VGND VPWR VPWR memory\[31\]\[23\] sky130_fd_sc_hd__dfxtp_1
Xhold163 memory\[30\]\[27\] VGND VGND VPWR VPWR net372 sky130_fd_sc_hd__dlygate4sd3_1
Xhold185 memory\[22\]\[15\] VGND VGND VPWR VPWR net394 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5499_ _2627_ _2776_ _2778_ net575 VGND VGND VPWR VPWR _0815_ sky130_fd_sc_hd__a22o_1
Xhold196 memory\[30\]\[17\] VGND VGND VPWR VPWR net405 sky130_fd_sc_hd__dlygate4sd3_1
X_7169_ clknet_leaf_80_clk _0760_ VGND VGND VPWR VPWR memory\[2\]\[18\] sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_97_clk clknet_4_4_0_clk VGND VGND VPWR VPWR clknet_leaf_97_clk sky130_fd_sc_hd__clkbuf_16
XTAP_490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_107_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_leaf_21_clk clknet_4_8_0_clk VGND VGND VPWR VPWR clknet_leaf_21_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_64_674 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_121_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_88_clk clknet_4_5_0_clk VGND VGND VPWR VPWR clknet_leaf_88_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_91_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_711 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_24_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4870_ net35 VGND VGND VPWR VPWR _2484_ sky130_fd_sc_hd__clkbuf_8
X_3821_ memory\[20\]\[16\] memory\[21\]\[16\] memory\[22\]\[16\] memory\[23\]\[16\]
+ _1509_ _1510_ VGND VGND VPWR VPWR _1511_ sky130_fd_sc_hd__mux4_1
XFILLER_0_46_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6540_ _3325_ VGND VGND VPWR VPWR _3339_ sky130_fd_sc_hd__buf_2
XFILLER_0_40_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3752_ memory\[12\]\[12\] memory\[13\]\[12\] memory\[14\]\[12\] memory\[15\]\[12\]
+ _1194_ _1195_ VGND VGND VPWR VPWR _1446_ sky130_fd_sc_hd__mux4_1
Xclkbuf_leaf_12_clk clknet_4_3_0_clk VGND VGND VPWR VPWR clknet_leaf_12_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_15_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_173 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_70_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6471_ _2865_ _3295_ VGND VGND VPWR VPWR _3299_ sky130_fd_sc_hd__and2_1
XFILLER_0_42_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3683_ _1155_ _1375_ _1377_ _1379_ _1184_ VGND VGND VPWR VPWR _1380_ sky130_fd_sc_hd__a221o_1
XFILLER_0_112_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5422_ _2467_ _2761_ _2762_ net375 VGND VGND VPWR VPWR _0754_ sky130_fd_sc_hd__a22o_1
X_5353_ _2481_ _2744_ _2745_ net386 VGND VGND VPWR VPWR _0702_ sky130_fd_sc_hd__a22o_1
XFILLER_0_2_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4304_ memory\[20\]\[6\] memory\[21\]\[6\] memory\[22\]\[6\] memory\[23\]\[6\] _1970_
+ _1971_ VGND VGND VPWR VPWR _1972_ sky130_fd_sc_hd__mux4_1
X_5284_ _2646_ _2708_ VGND VGND VPWR VPWR _2716_ sky130_fd_sc_hd__and2_1
X_7023_ clknet_leaf_1_clk _0614_ VGND VGND VPWR VPWR memory\[16\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_4235_ _1812_ _1905_ VGND VGND VPWR VPWR _1906_ sky130_fd_sc_hd__or2_1
Xclkbuf_leaf_79_clk clknet_4_7_0_clk VGND VGND VPWR VPWR clknet_leaf_79_clk sky130_fd_sc_hd__clkbuf_16
X_4166_ net4 VGND VGND VPWR VPWR _1840_ sky130_fd_sc_hd__buf_4
XFILLER_0_4_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_4_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4097_ _1205_ _1772_ _1153_ VGND VGND VPWR VPWR _1773_ sky130_fd_sc_hd__o21a_1
X_7925_ net188 _0060_ VGND VGND VPWR VPWR net78 sky130_fd_sc_hd__dfxtp_2
X_7856_ clknet_leaf_22_clk _0390_ VGND VGND VPWR VPWR memory\[13\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_81_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6807_ _2638_ _3441_ _3442_ net471 VGND VGND VPWR VPWR _0434_ sky130_fd_sc_hd__a22o_1
X_7787_ clknet_leaf_35_clk _0321_ VGND VGND VPWR VPWR memory\[30\]\[28\] sky130_fd_sc_hd__dfxtp_1
X_4999_ net1118 _2543_ _2540_ VGND VGND VPWR VPWR _2549_ sky130_fd_sc_hd__and3_1
X_6738_ net36 _3414_ VGND VGND VPWR VPWR _3423_ sky130_fd_sc_hd__and2_1
XFILLER_0_104_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6669_ _2676_ _3376_ _3378_ net956 VGND VGND VPWR VPWR _0355_ sky130_fd_sc_hd__a22o_1
XFILLER_0_61_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_96_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5555__30 clknet_1_1__leaf__2786_ VGND VGND VPWR VPWR net175 sky130_fd_sc_hd__inv_2
XFILLER_0_64_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_154 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_86_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_21 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_20_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4020_ _1591_ _1699_ _1595_ VGND VGND VPWR VPWR _1700_ sky130_fd_sc_hd__o21a_1
Xclkbuf_leaf_1_clk clknet_4_0_0_clk VGND VGND VPWR VPWR clknet_leaf_1_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_29_9 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5971_ _2861_ _3023_ VGND VGND VPWR VPWR _3025_ sky130_fd_sc_hd__and2_1
XFILLER_0_35_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4922_ _2487_ _2493_ _2495_ net312 VGND VGND VPWR VPWR _0515_ sky130_fd_sc_hd__a22o_1
X_7710_ clknet_leaf_86_clk _0244_ VGND VGND VPWR VPWR memory\[5\]\[15\] sky130_fd_sc_hd__dfxtp_1
X_7641_ clknet_leaf_93_clk _0175_ VGND VGND VPWR VPWR memory\[19\]\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_19_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4853_ _2474_ _2464_ _2465_ net226 VGND VGND VPWR VPWR _0472_ sky130_fd_sc_hd__a22o_1
XFILLER_0_51_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4784_ memory\[28\]\[31\] memory\[29\]\[31\] memory\[30\]\[31\] memory\[31\]\[31\]
+ _1821_ _1822_ VGND VGND VPWR VPWR _2427_ sky130_fd_sc_hd__mux4_1
X_7572_ clknet_leaf_114_clk _1131_ VGND VGND VPWR VPWR memory\[23\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_3804_ memory\[24\]\[15\] memory\[25\]\[15\] memory\[26\]\[15\] memory\[27\]\[15\]
+ _1353_ _1354_ VGND VGND VPWR VPWR _1495_ sky130_fd_sc_hd__mux4_1
XFILLER_0_27_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3735_ _1187_ VGND VGND VPWR VPWR _1430_ sky130_fd_sc_hd__clkbuf_8
X_6523_ net613 _3317_ _3324_ _3329_ VGND VGND VPWR VPWR _0263_ sky130_fd_sc_hd__a31o_1
X_6454_ _2849_ _3282_ VGND VGND VPWR VPWR _3289_ sky130_fd_sc_hd__and2_1
XFILLER_0_30_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5405_ _2757_ VGND VGND VPWR VPWR _2758_ sky130_fd_sc_hd__clkbuf_4
X_3666_ _1158_ VGND VGND VPWR VPWR _1364_ sky130_fd_sc_hd__buf_4
XFILLER_0_113_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_11_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6385_ net506 _3233_ _3236_ _3248_ VGND VGND VPWR VPWR _0206_ sky130_fd_sc_hd__a31o_1
XFILLER_0_23_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3597_ memory\[24\]\[5\] memory\[25\]\[5\] memory\[26\]\[5\] memory\[27\]\[5\] _1171_
+ _1173_ VGND VGND VPWR VPWR _1298_ sky130_fd_sc_hd__mux4_1
X_5336_ _2740_ VGND VGND VPWR VPWR _2743_ sky130_fd_sc_hd__clkbuf_4
X_5267_ net335 _2704_ _2693_ _2706_ VGND VGND VPWR VPWR _0655_ sky130_fd_sc_hd__a31o_1
X_7006_ clknet_leaf_93_clk _0597_ VGND VGND VPWR VPWR memory\[26\]\[15\] sky130_fd_sc_hd__dfxtp_1
X_4218_ _1820_ _1889_ _1824_ VGND VGND VPWR VPWR _1890_ sky130_fd_sc_hd__o21a_1
X_5198_ net1101 _2675_ _2605_ _2679_ VGND VGND VPWR VPWR _0613_ sky130_fd_sc_hd__a31o_1
X_4149_ memory\[28\]\[0\] memory\[29\]\[0\] memory\[30\]\[0\] memory\[31\]\[0\] _1821_
+ _1822_ VGND VGND VPWR VPWR _1823_ sky130_fd_sc_hd__mux4_1
XFILLER_0_78_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7908_ clknet_leaf_40_clk _0442_ VGND VGND VPWR VPWR memory\[17\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_65_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7839_ clknet_leaf_70_clk _0373_ VGND VGND VPWR VPWR memory\[9\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_93_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_205 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_19_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_46_460 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_33_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_116_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_213 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_84_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_112_13 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_717 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_4_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_44 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_114_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3520_ _1223_ _1224_ _1205_ VGND VGND VPWR VPWR _1225_ sky130_fd_sc_hd__mux2_1
Xhold718 memory\[20\]\[22\] VGND VGND VPWR VPWR net927 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_97_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold707 memory\[30\]\[9\] VGND VGND VPWR VPWR net916 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_110_502 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold729 memory\[17\]\[21\] VGND VGND VPWR VPWR net938 sky130_fd_sc_hd__dlygate4sd3_1
X_3451_ _1156_ VGND VGND VPWR VPWR _1157_ sky130_fd_sc_hd__buf_6
X_6170_ _2510_ _2490_ _3093_ VGND VGND VPWR VPWR _3139_ sky130_fd_sc_hd__and3_4
X_5121_ _2625_ _2609_ VGND VGND VPWR VPWR _2626_ sky130_fd_sc_hd__and2_1
X_5052_ _2471_ _2571_ _2580_ VGND VGND VPWR VPWR _0566_ sky130_fd_sc_hd__a21o_1
X_4003_ _1584_ _1679_ _1681_ _1683_ _1597_ VGND VGND VPWR VPWR _1684_ sky130_fd_sc_hd__a221o_1
XFILLER_0_46_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5954_ _2845_ _3010_ VGND VGND VPWR VPWR _3015_ sky130_fd_sc_hd__and2_1
X_4905_ _2470_ _2497_ _2498_ net338 VGND VGND VPWR VPWR _0500_ sky130_fd_sc_hd__a22o_1
X_5885_ net822 _2968_ _2963_ _2974_ VGND VGND VPWR VPWR _1005_ sky130_fd_sc_hd__a31o_1
XFILLER_0_118_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_117_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7624_ clknet_leaf_28_clk _0158_ VGND VGND VPWR VPWR memory\[27\]\[25\] sky130_fd_sc_hd__dfxtp_1
X_4836_ net18 VGND VGND VPWR VPWR _2466_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_7_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7555_ clknet_leaf_18_clk _1114_ VGND VGND VPWR VPWR memory\[20\]\[20\] sky130_fd_sc_hd__dfxtp_1
X_6506_ net373 _3317_ _3307_ _3318_ VGND VGND VPWR VPWR _0257_ sky130_fd_sc_hd__a31o_1
X_4767_ _1876_ _2410_ _1880_ VGND VGND VPWR VPWR _2411_ sky130_fd_sc_hd__o21a_1
XFILLER_0_55_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4698_ memory\[0\]\[26\] memory\[1\]\[26\] memory\[2\]\[26\] memory\[3\]\[26\] _1863_
+ _1864_ VGND VGND VPWR VPWR _2346_ sky130_fd_sc_hd__mux4_1
XFILLER_0_15_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7486_ clknet_leaf_91_clk _1045_ VGND VGND VPWR VPWR memory\[24\]\[15\] sky130_fd_sc_hd__dfxtp_1
X_3718_ _1404_ _1413_ VGND VGND VPWR VPWR _1414_ sky130_fd_sc_hd__and2_1
X_5534__11 clknet_1_0__leaf__2784_ VGND VGND VPWR VPWR net156 sky130_fd_sc_hd__inv_2
X_6437_ _2554_ _2960_ VGND VGND VPWR VPWR _3278_ sky130_fd_sc_hd__or2_1
XFILLER_0_15_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3649_ _1347_ VGND VGND VPWR VPWR _0029_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_101_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6368_ _2838_ _3238_ VGND VGND VPWR VPWR _3240_ sky130_fd_sc_hd__and2_1
X_5319_ net12 net11 VGND VGND VPWR VPWR _2736_ sky130_fd_sc_hd__nor2b_4
XFILLER_0_11_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_11_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6299_ _2886_ _3210_ VGND VGND VPWR VPWR _3214_ sky130_fd_sc_hd__and2_1
Xhold12 memory\[3\]\[30\] VGND VGND VPWR VPWR net221 sky130_fd_sc_hd__dlygate4sd3_1
Xhold23 memory\[19\]\[19\] VGND VGND VPWR VPWR net232 sky130_fd_sc_hd__dlygate4sd3_1
Xhold34 memory\[29\]\[20\] VGND VGND VPWR VPWR net243 sky130_fd_sc_hd__dlygate4sd3_1
Xhold45 memory\[13\]\[31\] VGND VGND VPWR VPWR net254 sky130_fd_sc_hd__dlygate4sd3_1
Xhold56 memory\[18\]\[13\] VGND VGND VPWR VPWR net265 sky130_fd_sc_hd__dlygate4sd3_1
Xhold78 memory\[12\]\[24\] VGND VGND VPWR VPWR net287 sky130_fd_sc_hd__dlygate4sd3_1
Xhold67 memory\[29\]\[19\] VGND VGND VPWR VPWR net276 sky130_fd_sc_hd__dlygate4sd3_1
Xhold89 memory\[30\]\[0\] VGND VGND VPWR VPWR net298 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_97_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_109_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_9 _1265_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_83_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_107_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_89_658 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_88_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1091 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1080 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5670_ net1049 _2844_ _2833_ _2854_ VGND VGND VPWR VPWR _0878_ sky130_fd_sc_hd__a31o_1
XFILLER_0_120_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4621_ _2113_ _2272_ VGND VGND VPWR VPWR _2273_ sky130_fd_sc_hd__or2_1
XFILLER_0_114_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7340_ clknet_leaf_49_clk _0899_ VGND VGND VPWR VPWR memory\[7\]\[29\] sky130_fd_sc_hd__dfxtp_1
X_4552_ memory\[0\]\[18\] memory\[1\]\[18\] memory\[2\]\[18\] memory\[3\]\[18\] _2017_
+ _2018_ VGND VGND VPWR VPWR _2208_ sky130_fd_sc_hd__mux4_1
XFILLER_0_25_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold526 memory\[18\]\[26\] VGND VGND VPWR VPWR net735 sky130_fd_sc_hd__dlygate4sd3_1
X_4483_ memory\[12\]\[14\] memory\[13\]\[14\] memory\[14\]\[14\] memory\[15\]\[14\]
+ _2045_ _2046_ VGND VGND VPWR VPWR _2143_ sky130_fd_sc_hd__mux4_1
X_7271_ net174 _0016_ VGND VGND VPWR VPWR net98 sky130_fd_sc_hd__dfxtp_1
Xhold504 memory\[21\]\[4\] VGND VGND VPWR VPWR net713 sky130_fd_sc_hd__dlygate4sd3_1
Xhold515 memory\[22\]\[17\] VGND VGND VPWR VPWR net724 sky130_fd_sc_hd__dlygate4sd3_1
X_3503_ _1192_ _1198_ _1206_ _1207_ _1208_ VGND VGND VPWR VPWR _1209_ sky130_fd_sc_hd__a221o_1
XFILLER_0_122_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6222_ net569 _3159_ _3166_ _3169_ VGND VGND VPWR VPWR _1147_ sky130_fd_sc_hd__a31o_1
Xhold537 memory\[31\]\[6\] VGND VGND VPWR VPWR net746 sky130_fd_sc_hd__dlygate4sd3_1
Xhold559 memory\[19\]\[18\] VGND VGND VPWR VPWR net768 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold548 memory\[9\]\[6\] VGND VGND VPWR VPWR net757 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_110_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_110_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6153_ _2893_ _3123_ VGND VGND VPWR VPWR _3129_ sky130_fd_sc_hd__and2_1
XFILLER_0_0_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_820 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_831 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_842 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_853 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6084_ _2899_ _3079_ VGND VGND VPWR VPWR _3089_ sky130_fd_sc_hd__and2_1
XFILLER_0_57_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5104_ net734 _2601_ _2606_ _2614_ VGND VGND VPWR VPWR _0584_ sky130_fd_sc_hd__a31o_1
XTAP_875 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_864 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_886 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5035_ _2462_ _2556_ _2570_ VGND VGND VPWR VPWR _0559_ sky130_fd_sc_hd__a21o_1
XTAP_897 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6986_ clknet_leaf_49_clk _0577_ VGND VGND VPWR VPWR memory\[6\]\[27\] sky130_fd_sc_hd__dfxtp_1
X_5937_ net268 _2994_ _2962_ _3003_ VGND VGND VPWR VPWR _1028_ sky130_fd_sc_hd__a31o_1
XFILLER_0_48_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7607_ clknet_leaf_2_clk _0141_ VGND VGND VPWR VPWR memory\[27\]\[8\] sky130_fd_sc_hd__dfxtp_1
X_5868_ _2964_ VGND VGND VPWR VPWR _2965_ sky130_fd_sc_hd__buf_2
XFILLER_0_106_616 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5799_ net1157 _2597_ _2921_ VGND VGND VPWR VPWR _2925_ sky130_fd_sc_hd__and3_1
X_4819_ _2456_ _2449_ _2453_ net592 VGND VGND VPWR VPWR _0456_ sky130_fd_sc_hd__a22o_1
XFILLER_0_105_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7538_ clknet_leaf_114_clk _1097_ VGND VGND VPWR VPWR memory\[20\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_43_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7469_ clknet_leaf_47_clk _1028_ VGND VGND VPWR VPWR memory\[1\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_101_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput57 net57 VGND VGND VPWR VPWR data_out1[16] sky130_fd_sc_hd__clkbuf_4
Xoutput68 net68 VGND VGND VPWR VPWR data_out1[26] sky130_fd_sc_hd__clkbuf_4
Xoutput79 net79 VGND VGND VPWR VPWR data_out1[7] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_98_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_105_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_77_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6771_ _2648_ _3432_ _3433_ net280 VGND VGND VPWR VPWR _0407_ sky130_fd_sc_hd__a22o_1
XFILLER_0_43_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3983_ memory\[28\]\[24\] memory\[29\]\[24\] memory\[30\]\[24\] memory\[31\]\[24\]
+ _1592_ _1593_ VGND VGND VPWR VPWR _1665_ sky130_fd_sc_hd__mux4_1
XFILLER_0_119_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5722_ net32 VGND VGND VPWR VPWR _2891_ sky130_fd_sc_hd__buf_4
XFILLER_0_9_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_600 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5653_ _2842_ _2836_ VGND VGND VPWR VPWR _2843_ sky130_fd_sc_hd__and2_1
X_4604_ memory\[28\]\[21\] memory\[29\]\[21\] memory\[30\]\[21\] memory\[31\]\[21\]
+ _2092_ _2093_ VGND VGND VPWR VPWR _2257_ sky130_fd_sc_hd__mux4_1
XFILLER_0_60_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5584_ _2625_ _2791_ VGND VGND VPWR VPWR _2801_ sky130_fd_sc_hd__and2_1
X_4535_ _2189_ _2190_ _2191_ VGND VGND VPWR VPWR _2192_ sky130_fd_sc_hd__mux2_1
XFILLER_0_4_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7323_ clknet_leaf_87_clk _0882_ VGND VGND VPWR VPWR memory\[7\]\[12\] sky130_fd_sc_hd__dfxtp_1
Xhold301 memory\[3\]\[3\] VGND VGND VPWR VPWR net510 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_102_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold334 memory\[17\]\[7\] VGND VGND VPWR VPWR net543 sky130_fd_sc_hd__dlygate4sd3_1
Xhold323 memory\[19\]\[17\] VGND VGND VPWR VPWR net532 sky130_fd_sc_hd__dlygate4sd3_1
Xhold312 memory\[31\]\[1\] VGND VGND VPWR VPWR net521 sky130_fd_sc_hd__dlygate4sd3_1
Xhold356 memory\[11\]\[23\] VGND VGND VPWR VPWR net565 sky130_fd_sc_hd__dlygate4sd3_1
Xhold367 memory\[18\]\[23\] VGND VGND VPWR VPWR net576 sky130_fd_sc_hd__dlygate4sd3_1
Xhold378 memory\[15\]\[11\] VGND VGND VPWR VPWR net587 sky130_fd_sc_hd__dlygate4sd3_1
Xhold345 memory\[23\]\[2\] VGND VGND VPWR VPWR net554 sky130_fd_sc_hd__dlygate4sd3_1
X_4466_ _2125_ _2126_ _1809_ VGND VGND VPWR VPWR _2127_ sky130_fd_sc_hd__mux2_1
X_7254_ net157 _0029_ VGND VGND VPWR VPWR net111 sky130_fd_sc_hd__dfxtp_2
XFILLER_0_111_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold389 memory\[18\]\[29\] VGND VGND VPWR VPWR net598 sky130_fd_sc_hd__dlygate4sd3_1
X_4397_ memory\[12\]\[10\] memory\[13\]\[10\] memory\[14\]\[10\] memory\[15\]\[10\]
+ _1973_ _1974_ VGND VGND VPWR VPWR _2061_ sky130_fd_sc_hd__mux4_1
X_7185_ clknet_leaf_6_clk _0776_ VGND VGND VPWR VPWR memory\[14\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_6205_ _2868_ _3154_ VGND VGND VPWR VPWR _3160_ sky130_fd_sc_hd__and2_1
XFILLER_0_0_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6136_ net873 _3117_ _3109_ _3119_ VGND VGND VPWR VPWR _1111_ sky130_fd_sc_hd__a31o_1
XTAP_650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6067_ _2881_ _3079_ VGND VGND VPWR VPWR _3080_ sky130_fd_sc_hd__and2_1
X_5018_ net1125 _2557_ _2560_ VGND VGND VPWR VPWR _2562_ sky130_fd_sc_hd__and3_1
XTAP_1805 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1816 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1849 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1838 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1827 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_458 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6969_ clknet_leaf_84_clk _0560_ VGND VGND VPWR VPWR memory\[6\]\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_48_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_118_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_528 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_121_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold890 memory\[9\]\[25\] VGND VGND VPWR VPWR net1099 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_101_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_58_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_112_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4320_ _1979_ _1987_ VGND VGND VPWR VPWR _1988_ sky130_fd_sc_hd__and2_1
XFILLER_0_2_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4251_ memory\[20\]\[4\] memory\[21\]\[4\] memory\[22\]\[4\] memory\[23\]\[4\] _1800_
+ _1802_ VGND VGND VPWR VPWR _1921_ sky130_fd_sc_hd__mux4_1
X_4182_ memory\[16\]\[1\] memory\[17\]\[1\] memory\[18\]\[1\] memory\[19\]\[1\] _1804_
+ _1805_ VGND VGND VPWR VPWR _1855_ sky130_fd_sc_hd__mux4_1
X_7941_ net204 _0046_ VGND VGND VPWR VPWR net64 sky130_fd_sc_hd__dfxtp_1
X_7872_ clknet_leaf_65_clk _0406_ VGND VGND VPWR VPWR memory\[13\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_54_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6823_ _2669_ _3443_ _3444_ net999 VGND VGND VPWR VPWR _0448_ sky130_fd_sc_hd__a22o_1
XFILLER_0_58_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3966_ _1591_ _1648_ _1595_ VGND VGND VPWR VPWR _1649_ sky130_fd_sc_hd__o21a_1
X_6754_ _2615_ _3429_ _3431_ net493 VGND VGND VPWR VPWR _0392_ sky130_fd_sc_hd__a22o_1
XFILLER_0_9_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5705_ _2878_ _2859_ VGND VGND VPWR VPWR _2879_ sky130_fd_sc_hd__and2_1
X_6685_ net42 _3388_ VGND VGND VPWR VPWR _3394_ sky130_fd_sc_hd__and2_1
XFILLER_0_115_210 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_92_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5636_ _2678_ _2790_ VGND VGND VPWR VPWR _2830_ sky130_fd_sc_hd__and2_1
XFILLER_0_72_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3897_ _1583_ VGND VGND VPWR VPWR _0010_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_103_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5567_ _2607_ _2791_ VGND VGND VPWR VPWR _2792_ sky130_fd_sc_hd__and2_1
Xhold131 memory\[28\]\[24\] VGND VGND VPWR VPWR net340 sky130_fd_sc_hd__dlygate4sd3_1
X_7306_ clknet_leaf_51_clk _0865_ VGND VGND VPWR VPWR memory\[8\]\[27\] sky130_fd_sc_hd__dfxtp_1
Xhold153 memory\[16\]\[23\] VGND VGND VPWR VPWR net362 sky130_fd_sc_hd__dlygate4sd3_1
Xhold120 memory\[29\]\[10\] VGND VGND VPWR VPWR net329 sky130_fd_sc_hd__dlygate4sd3_1
X_4518_ memory\[4\]\[16\] memory\[5\]\[16\] memory\[6\]\[16\] memory\[7\]\[16\] _1842_
+ _1843_ VGND VGND VPWR VPWR _2176_ sky130_fd_sc_hd__mux4_1
Xhold142 memory\[31\]\[19\] VGND VGND VPWR VPWR net351 sky130_fd_sc_hd__dlygate4sd3_1
X_5498_ _2625_ _2776_ _2778_ net446 VGND VGND VPWR VPWR _0814_ sky130_fd_sc_hd__a22o_1
X_7237_ clknet_leaf_38_clk _0828_ VGND VGND VPWR VPWR memory\[31\]\[22\] sky130_fd_sc_hd__dfxtp_1
Xhold164 memory\[5\]\[28\] VGND VGND VPWR VPWR net373 sky130_fd_sc_hd__dlygate4sd3_1
Xhold186 memory\[12\]\[2\] VGND VGND VPWR VPWR net395 sky130_fd_sc_hd__dlygate4sd3_1
X_4449_ memory\[20\]\[13\] memory\[21\]\[13\] memory\[22\]\[13\] memory\[23\]\[13\]
+ _1938_ _1939_ VGND VGND VPWR VPWR _2110_ sky130_fd_sc_hd__mux4_1
Xhold175 memory\[17\]\[2\] VGND VGND VPWR VPWR net384 sky130_fd_sc_hd__dlygate4sd3_1
Xhold197 memory\[9\]\[21\] VGND VGND VPWR VPWR net406 sky130_fd_sc_hd__dlygate4sd3_1
X_7168_ clknet_leaf_69_clk _0759_ VGND VGND VPWR VPWR memory\[2\]\[17\] sky130_fd_sc_hd__dfxtp_1
XTAP_480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6119_ _3096_ VGND VGND VPWR VPWR _3110_ sky130_fd_sc_hd__buf_2
XTAP_491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7099_ clknet_leaf_86_clk _0690_ VGND VGND VPWR VPWR memory\[29\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_95_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_20_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_102_482 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_87_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_115_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3820_ _1158_ VGND VGND VPWR VPWR _1510_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_27_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3751_ _1186_ _1444_ VGND VGND VPWR VPWR _1445_ sky130_fd_sc_hd__or2_1
XFILLER_0_70_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6470_ net880 _3291_ _3294_ _3298_ VGND VGND VPWR VPWR _0241_ sky130_fd_sc_hd__a31o_1
X_3682_ _1177_ _1378_ _1181_ VGND VGND VPWR VPWR _1379_ sky130_fd_sc_hd__o21a_1
XFILLER_0_54_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5421_ _2466_ _2761_ _2762_ net455 VGND VGND VPWR VPWR _0753_ sky130_fd_sc_hd__a22o_1
X_5352_ _2480_ _2744_ _2745_ net236 VGND VGND VPWR VPWR _0701_ sky130_fd_sc_hd__a22o_1
XFILLER_0_23_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4303_ _1832_ VGND VGND VPWR VPWR _1971_ sky130_fd_sc_hd__clkbuf_8
X_7022_ clknet_leaf_21_clk _0613_ VGND VGND VPWR VPWR memory\[26\]\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_10_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5283_ net814 _2704_ _2707_ _2715_ VGND VGND VPWR VPWR _0662_ sky130_fd_sc_hd__a31o_1
X_4234_ memory\[24\]\[3\] memory\[25\]\[3\] memory\[26\]\[3\] memory\[27\]\[3\] _1814_
+ _1816_ VGND VGND VPWR VPWR _1905_ sky130_fd_sc_hd__mux4_1
X_4165_ memory\[12\]\[0\] memory\[13\]\[0\] memory\[14\]\[0\] memory\[15\]\[0\] _1837_
+ _1838_ VGND VGND VPWR VPWR _1839_ sky130_fd_sc_hd__mux4_1
XFILLER_0_4_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4096_ memory\[12\]\[30\] memory\[13\]\[30\] memory\[14\]\[30\] memory\[15\]\[30\]
+ _1188_ _1190_ VGND VGND VPWR VPWR _1772_ sky130_fd_sc_hd__mux4_1
XFILLER_0_77_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7924_ net187 _0059_ VGND VGND VPWR VPWR net77 sky130_fd_sc_hd__dfxtp_1
X_7855_ clknet_leaf_22_clk _0389_ VGND VGND VPWR VPWR memory\[13\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_108_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6806_ _2636_ _3441_ _3442_ net365 VGND VGND VPWR VPWR _0433_ sky130_fd_sc_hd__a22o_1
X_4998_ _2483_ _2539_ _2548_ VGND VGND VPWR VPWR _0544_ sky130_fd_sc_hd__a21o_1
X_7786_ clknet_leaf_34_clk _0320_ VGND VGND VPWR VPWR memory\[30\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_18_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_46_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6737_ net574 _2509_ _3413_ _3422_ VGND VGND VPWR VPWR _0384_ sky130_fd_sc_hd__a31o_1
X_3949_ _1584_ _1628_ _1630_ _1632_ _1597_ VGND VGND VPWR VPWR _1633_ sky130_fd_sc_hd__a221o_1
X_6668_ _2673_ _3382_ _3383_ net516 VGND VGND VPWR VPWR _0354_ sky130_fd_sc_hd__a22o_1
XFILLER_0_61_623 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_18_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5619_ _2661_ _2817_ VGND VGND VPWR VPWR _2821_ sky130_fd_sc_hd__and2_1
XFILLER_0_104_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6599_ _2619_ _3368_ _3370_ net850 VGND VGND VPWR VPWR _0298_ sky130_fd_sc_hd__a22o_1
XFILLER_0_14_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_117_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_101_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_52_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_122_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_99_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5970_ net637 _3021_ _3022_ _3024_ VGND VGND VPWR VPWR _1040_ sky130_fd_sc_hd__a31o_1
X_4921_ _2486_ _2499_ _2500_ net747 VGND VGND VPWR VPWR _0514_ sky130_fd_sc_hd__a22o_1
XFILLER_0_87_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4852_ net26 VGND VGND VPWR VPWR _2474_ sky130_fd_sc_hd__clkbuf_8
X_7640_ clknet_leaf_111_clk _0174_ VGND VGND VPWR VPWR memory\[19\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_7_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3803_ _1492_ _1493_ _1472_ VGND VGND VPWR VPWR _1494_ sky130_fd_sc_hd__mux2_1
X_4783_ _1812_ _2425_ VGND VGND VPWR VPWR _2426_ sky130_fd_sc_hd__or2_1
X_7571_ clknet_leaf_111_clk _1130_ VGND VGND VPWR VPWR memory\[23\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_3734_ _1245_ _1428_ VGND VGND VPWR VPWR _1429_ sky130_fd_sc_hd__or2_1
X_6522_ _2840_ _3326_ VGND VGND VPWR VPWR _3329_ sky130_fd_sc_hd__and2_1
XFILLER_0_82_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6453_ net885 _3275_ _3280_ _3288_ VGND VGND VPWR VPWR _0234_ sky130_fd_sc_hd__a31o_1
XFILLER_0_15_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3665_ _1156_ VGND VGND VPWR VPWR _1363_ sky130_fd_sc_hd__clkbuf_8
X_5404_ _2756_ VGND VGND VPWR VPWR _2757_ sky130_fd_sc_hd__buf_4
XFILLER_0_70_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3596_ _1295_ _1296_ _1279_ VGND VGND VPWR VPWR _1297_ sky130_fd_sc_hd__mux2_1
X_6384_ _2855_ _3238_ VGND VGND VPWR VPWR _3248_ sky130_fd_sc_hd__and2_1
XFILLER_0_30_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5335_ _2738_ VGND VGND VPWR VPWR _2742_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_55_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5266_ _2627_ _2695_ VGND VGND VPWR VPWR _2706_ sky130_fd_sc_hd__and2_1
X_7005_ clknet_leaf_96_clk _0596_ VGND VGND VPWR VPWR memory\[26\]\[14\] sky130_fd_sc_hd__dfxtp_1
X_4217_ memory\[28\]\[2\] memory\[29\]\[2\] memory\[30\]\[2\] memory\[31\]\[2\] _1821_
+ _1822_ VGND VGND VPWR VPWR _1889_ sky130_fd_sc_hd__mux4_1
X_5197_ _2678_ _2608_ VGND VGND VPWR VPWR _2679_ sky130_fd_sc_hd__and2_1
XFILLER_0_97_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4148_ _1815_ VGND VGND VPWR VPWR _1822_ sky130_fd_sc_hd__clkbuf_8
X_4079_ memory\[8\]\[29\] memory\[9\]\[29\] memory\[10\]\[29\] memory\[11\]\[29\]
+ _1194_ _1195_ VGND VGND VPWR VPWR _1756_ sky130_fd_sc_hd__mux4_1
X_7907_ clknet_leaf_31_clk _0441_ VGND VGND VPWR VPWR memory\[17\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_93_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7838_ clknet_leaf_77_clk _0372_ VGND VGND VPWR VPWR memory\[9\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_18_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7769_ clknet_leaf_98_clk _0303_ VGND VGND VPWR VPWR memory\[30\]\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_80_217 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_19_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_34_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_431 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_88_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_112_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold708 memory\[14\]\[6\] VGND VGND VPWR VPWR net917 sky130_fd_sc_hd__dlygate4sd3_1
Xhold719 memory\[27\]\[8\] VGND VGND VPWR VPWR net928 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_52_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_110_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3450_ net6 VGND VGND VPWR VPWR _1156_ sky130_fd_sc_hd__clkbuf_8
X_5120_ net46 VGND VGND VPWR VPWR _2625_ sky130_fd_sc_hd__buf_4
XFILLER_0_20_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5051_ net1168 _2572_ _2573_ VGND VGND VPWR VPWR _2580_ sky130_fd_sc_hd__and3_1
X_4002_ _1591_ _1682_ _1595_ VGND VGND VPWR VPWR _1683_ sky130_fd_sc_hd__o21a_1
XFILLER_0_94_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5953_ net882 _3006_ _3008_ _3014_ VGND VGND VPWR VPWR _1033_ sky130_fd_sc_hd__a31o_1
XFILLER_0_48_715 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4904_ _2469_ _2497_ _2498_ net572 VGND VGND VPWR VPWR _0499_ sky130_fd_sc_hd__a22o_1
X_5884_ _2851_ _2965_ VGND VGND VPWR VPWR _2974_ sky130_fd_sc_hd__and2_1
XFILLER_0_47_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_118_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_7623_ clknet_leaf_30_clk _0157_ VGND VGND VPWR VPWR memory\[27\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_90_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_63_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4835_ _2463_ _2464_ _2465_ net898 VGND VGND VPWR VPWR _0463_ sky130_fd_sc_hd__a22o_1
XFILLER_0_118_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4766_ memory\[28\]\[30\] memory\[29\]\[30\] memory\[30\]\[30\] memory\[31\]\[30\]
+ _1814_ _1816_ VGND VGND VPWR VPWR _2410_ sky130_fd_sc_hd__mux4_1
X_7554_ clknet_leaf_95_clk _1113_ VGND VGND VPWR VPWR memory\[20\]\[19\] sky130_fd_sc_hd__dfxtp_1
X_6505_ _2899_ _3308_ VGND VGND VPWR VPWR _3318_ sky130_fd_sc_hd__and2_1
XFILLER_0_16_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3717_ _1236_ _1407_ _1409_ _1411_ _1412_ VGND VGND VPWR VPWR _1413_ sky130_fd_sc_hd__a221o_1
X_4697_ memory\[4\]\[26\] memory\[5\]\[26\] memory\[6\]\[26\] memory\[7\]\[26\] _1813_
+ _1815_ VGND VGND VPWR VPWR _2345_ sky130_fd_sc_hd__mux4_1
X_7485_ clknet_leaf_97_clk _1044_ VGND VGND VPWR VPWR memory\[24\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_101_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_30_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6436_ net855 _3275_ _3235_ _3277_ VGND VGND VPWR VPWR _0228_ sky130_fd_sc_hd__a31o_1
X_3648_ _1338_ _1346_ VGND VGND VPWR VPWR _1347_ sky130_fd_sc_hd__and2_1
X_6367_ net884 _3233_ _3236_ _3239_ VGND VGND VPWR VPWR _0197_ sky130_fd_sc_hd__a31o_1
X_3579_ memory\[24\]\[4\] memory\[25\]\[4\] memory\[26\]\[4\] memory\[27\]\[4\] _1171_
+ _1173_ VGND VGND VPWR VPWR _1281_ sky130_fd_sc_hd__mux4_1
XFILLER_0_30_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5318_ net470 _2731_ _2692_ _2735_ VGND VGND VPWR VPWR _0677_ sky130_fd_sc_hd__a31o_1
X_6298_ _3145_ VGND VGND VPWR VPWR _3213_ sky130_fd_sc_hd__clkbuf_4
Xhold13 memory\[29\]\[2\] VGND VGND VPWR VPWR net222 sky130_fd_sc_hd__dlygate4sd3_1
Xhold46 memory\[18\]\[28\] VGND VGND VPWR VPWR net255 sky130_fd_sc_hd__dlygate4sd3_1
Xhold24 memory\[19\]\[28\] VGND VGND VPWR VPWR net233 sky130_fd_sc_hd__dlygate4sd3_1
Xhold35 memory\[3\]\[16\] VGND VGND VPWR VPWR net244 sky130_fd_sc_hd__dlygate4sd3_1
X_5249_ _2611_ _2695_ VGND VGND VPWR VPWR _2697_ sky130_fd_sc_hd__and2_1
Xhold79 memory\[28\]\[29\] VGND VGND VPWR VPWR net288 sky130_fd_sc_hd__dlygate4sd3_1
Xhold68 memory\[1\]\[19\] VGND VGND VPWR VPWR net277 sky130_fd_sc_hd__dlygate4sd3_1
Xhold57 memory\[29\]\[9\] VGND VGND VPWR VPWR net266 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_97_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_93_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_84_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1092 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1081 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1070 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4620_ memory\[24\]\[22\] memory\[25\]\[22\] memory\[26\]\[22\] memory\[27\]\[22\]
+ _2032_ _2033_ VGND VGND VPWR VPWR _2272_ sky130_fd_sc_hd__mux4_1
XFILLER_0_32_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_113_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_114_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4551_ memory\[4\]\[18\] memory\[5\]\[18\] memory\[6\]\[18\] memory\[7\]\[18\] _2014_
+ _2015_ VGND VGND VPWR VPWR _2207_ sky130_fd_sc_hd__mux4_1
XFILLER_0_13_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3502_ net10 VGND VGND VPWR VPWR _1208_ sky130_fd_sc_hd__clkbuf_4
X_7270_ net173 _0015_ VGND VGND VPWR VPWR net97 sky130_fd_sc_hd__dfxtp_1
Xhold516 memory\[8\]\[7\] VGND VGND VPWR VPWR net725 sky130_fd_sc_hd__dlygate4sd3_1
Xhold505 memory\[26\]\[3\] VGND VGND VPWR VPWR net714 sky130_fd_sc_hd__dlygate4sd3_1
Xhold527 memory\[11\]\[5\] VGND VGND VPWR VPWR net736 sky130_fd_sc_hd__dlygate4sd3_1
X_4482_ _2101_ _2141_ VGND VGND VPWR VPWR _2142_ sky130_fd_sc_hd__or2_1
Xhold538 memory\[15\]\[29\] VGND VGND VPWR VPWR net747 sky130_fd_sc_hd__dlygate4sd3_1
X_6221_ _2884_ _3167_ VGND VGND VPWR VPWR _3169_ sky130_fd_sc_hd__and2_1
Xhold549 memory\[13\]\[8\] VGND VGND VPWR VPWR net758 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_520 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6152_ net896 _3117_ _3122_ _3128_ VGND VGND VPWR VPWR _1118_ sky130_fd_sc_hd__a31o_1
XFILLER_0_40_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_810 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_110_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5103_ _2613_ _2609_ VGND VGND VPWR VPWR _2614_ sky130_fd_sc_hd__and2_1
XTAP_821 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_832 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_843 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6083_ _3005_ VGND VGND VPWR VPWR _3088_ sky130_fd_sc_hd__buf_6
XTAP_854 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_876 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_865 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5034_ memory\[6\]\[9\] _2557_ _2560_ VGND VGND VPWR VPWR _2570_ sky130_fd_sc_hd__and3_1
XTAP_887 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_898 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6985_ clknet_leaf_64_clk _0576_ VGND VGND VPWR VPWR memory\[6\]\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_67_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5936_ _2903_ _2964_ VGND VGND VPWR VPWR _3003_ sky130_fd_sc_hd__and2_1
XFILLER_0_75_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5867_ _2746_ _2690_ _2736_ VGND VGND VPWR VPWR _2964_ sky130_fd_sc_hd__and3_2
X_7606_ clknet_leaf_2_clk _0140_ VGND VGND VPWR VPWR memory\[27\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_4818_ net41 VGND VGND VPWR VPWR _2456_ sky130_fd_sc_hd__buf_4
X_5798_ _2455_ _2919_ _2924_ VGND VGND VPWR VPWR _0936_ sky130_fd_sc_hd__a21o_1
X_4749_ _2392_ _2393_ _1848_ VGND VGND VPWR VPWR _2394_ sky130_fd_sc_hd__mux2_1
X_7537_ clknet_leaf_114_clk _1096_ VGND VGND VPWR VPWR memory\[20\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_50_209 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_7468_ clknet_leaf_57_clk _1027_ VGND VGND VPWR VPWR memory\[1\]\[29\] sky130_fd_sc_hd__dfxtp_1
X_6419_ net1090 _3262_ _3263_ _3268_ VGND VGND VPWR VPWR _0220_ sky130_fd_sc_hd__a31o_1
XFILLER_0_3_380 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_7399_ clknet_leaf_30_clk _0958_ VGND VGND VPWR VPWR memory\[25\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_12_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput58 net58 VGND VGND VPWR VPWR data_out1[17] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_31_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput69 net69 VGND VGND VPWR VPWR data_out1[27] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_98_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_78_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_118_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_89_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3982_ _1588_ _1663_ VGND VGND VPWR VPWR _1664_ sky130_fd_sc_hd__or2_1
X_6770_ _2646_ _3432_ _3433_ net216 VGND VGND VPWR VPWR _0406_ sky130_fd_sc_hd__a22o_1
XFILLER_0_69_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5721_ _2730_ VGND VGND VPWR VPWR _2890_ sky130_fd_sc_hd__buf_4
XFILLER_0_84_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_57_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_115_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5652_ net41 VGND VGND VPWR VPWR _2842_ sky130_fd_sc_hd__buf_4
XFILLER_0_5_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_115_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4603_ _2113_ _2255_ VGND VGND VPWR VPWR _2256_ sky130_fd_sc_hd__or2_1
X_5583_ net725 _2798_ _2789_ _2800_ VGND VGND VPWR VPWR _0845_ sky130_fd_sc_hd__a31o_1
X_4534_ _1807_ VGND VGND VPWR VPWR _2191_ sky130_fd_sc_hd__buf_4
Xhold302 memory\[14\]\[13\] VGND VGND VPWR VPWR net511 sky130_fd_sc_hd__dlygate4sd3_1
X_7322_ clknet_leaf_84_clk _0881_ VGND VGND VPWR VPWR memory\[7\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_41_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold313 memory\[31\]\[16\] VGND VGND VPWR VPWR net522 sky130_fd_sc_hd__dlygate4sd3_1
Xhold324 memory\[26\]\[19\] VGND VGND VPWR VPWR net533 sky130_fd_sc_hd__dlygate4sd3_1
Xhold335 memory\[1\]\[13\] VGND VGND VPWR VPWR net544 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_111_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold357 memory\[9\]\[30\] VGND VGND VPWR VPWR net566 sky130_fd_sc_hd__dlygate4sd3_1
Xhold368 memory\[20\]\[20\] VGND VGND VPWR VPWR net577 sky130_fd_sc_hd__dlygate4sd3_1
Xhold346 memory\[26\]\[10\] VGND VGND VPWR VPWR net555 sky130_fd_sc_hd__dlygate4sd3_1
X_7253_ net156 _0028_ VGND VGND VPWR VPWR net110 sky130_fd_sc_hd__dfxtp_2
X_4465_ memory\[0\]\[13\] memory\[1\]\[13\] memory\[2\]\[13\] memory\[3\]\[13\] _1845_
+ _1846_ VGND VGND VPWR VPWR _2126_ sky130_fd_sc_hd__mux4_1
XFILLER_0_111_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_7184_ clknet_leaf_22_clk _0775_ VGND VGND VPWR VPWR memory\[14\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_4396_ _1829_ _2059_ VGND VGND VPWR VPWR _2060_ sky130_fd_sc_hd__or2_1
XFILLER_0_7_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold379 memory\[30\]\[13\] VGND VGND VPWR VPWR net588 sky130_fd_sc_hd__dlygate4sd3_1
X_6204_ _3145_ VGND VGND VPWR VPWR _3159_ sky130_fd_sc_hd__buf_4
X_6855__62 clknet_1_0__leaf__3446_ VGND VGND VPWR VPWR net207 sky130_fd_sc_hd__inv_2
X_6135_ _2874_ _3110_ VGND VGND VPWR VPWR _3119_ sky130_fd_sc_hd__and2_1
XTAP_640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6066_ _3052_ VGND VGND VPWR VPWR _3079_ sky130_fd_sc_hd__buf_2
XTAP_662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_72 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5017_ _2439_ _2556_ _2561_ VGND VGND VPWR VPWR _0550_ sky130_fd_sc_hd__a21o_1
XTAP_1806 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1839 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1828 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1817 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6968_ clknet_leaf_107_clk _0559_ VGND VGND VPWR VPWR memory\[6\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_48_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5919_ _2730_ VGND VGND VPWR VPWR _2994_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_76_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6899_ clknet_leaf_22_clk _0490_ VGND VGND VPWR VPWR memory\[15\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_63_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_106_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_106_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold880 memory\[24\]\[22\] VGND VGND VPWR VPWR net1089 sky130_fd_sc_hd__dlygate4sd3_1
Xhold891 memory\[8\]\[16\] VGND VGND VPWR VPWR net1100 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_7_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_98_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_98_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_86_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_39_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_109_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_109_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_109_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_82_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_105_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_562 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_1_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_120_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4250_ _1920_ VGND VGND VPWR VPWR _0057_ sky130_fd_sc_hd__buf_1
X_4181_ memory\[20\]\[1\] memory\[21\]\[1\] memory\[22\]\[1\] memory\[23\]\[1\] _1800_
+ _1802_ VGND VGND VPWR VPWR _1854_ sky130_fd_sc_hd__mux4_1
X_7940_ net203 _0045_ VGND VGND VPWR VPWR net63 sky130_fd_sc_hd__dfxtp_1
X_7871_ clknet_leaf_67_clk _0405_ VGND VGND VPWR VPWR memory\[13\]\[16\] sky130_fd_sc_hd__dfxtp_1
X_6822_ _2667_ _3443_ _3444_ net871 VGND VGND VPWR VPWR _0447_ sky130_fd_sc_hd__a22o_1
XFILLER_0_9_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3965_ memory\[28\]\[23\] memory\[29\]\[23\] memory\[30\]\[23\] memory\[31\]\[23\]
+ _1592_ _1593_ VGND VGND VPWR VPWR _1648_ sky130_fd_sc_hd__mux4_1
XFILLER_0_73_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6753_ _2613_ _3429_ _3431_ net302 VGND VGND VPWR VPWR _0391_ sky130_fd_sc_hd__a22o_1
XFILLER_0_9_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_116_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5704_ net26 VGND VGND VPWR VPWR _2878_ sky130_fd_sc_hd__buf_4
XFILLER_0_9_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3896_ _1574_ _1582_ VGND VGND VPWR VPWR _1583_ sky130_fd_sc_hd__and2_1
X_6684_ _2508_ VGND VGND VPWR VPWR _3393_ sky130_fd_sc_hd__buf_4
XFILLER_0_115_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5635_ net848 _2824_ _2788_ _2829_ VGND VGND VPWR VPWR _0868_ sky130_fd_sc_hd__a31o_1
XFILLER_0_5_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_464 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5566_ _2790_ VGND VGND VPWR VPWR _2791_ sky130_fd_sc_hd__buf_2
XFILLER_0_60_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold110 memory\[2\]\[2\] VGND VGND VPWR VPWR net319 sky130_fd_sc_hd__dlygate4sd3_1
Xhold132 memory\[31\]\[29\] VGND VGND VPWR VPWR net341 sky130_fd_sc_hd__dlygate4sd3_1
X_7305_ clknet_leaf_51_clk _0864_ VGND VGND VPWR VPWR memory\[8\]\[26\] sky130_fd_sc_hd__dfxtp_1
Xhold121 memory\[8\]\[25\] VGND VGND VPWR VPWR net330 sky130_fd_sc_hd__dlygate4sd3_1
X_4517_ _1836_ _2174_ _1840_ VGND VGND VPWR VPWR _2175_ sky130_fd_sc_hd__o21a_1
Xhold143 memory\[3\]\[14\] VGND VGND VPWR VPWR net352 sky130_fd_sc_hd__dlygate4sd3_1
X_5497_ _2623_ _2776_ _2778_ net591 VGND VGND VPWR VPWR _0813_ sky130_fd_sc_hd__a22o_1
XFILLER_0_13_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7236_ clknet_leaf_37_clk _0827_ VGND VGND VPWR VPWR memory\[31\]\[21\] sky130_fd_sc_hd__dfxtp_1
Xhold165 memory\[4\]\[23\] VGND VGND VPWR VPWR net374 sky130_fd_sc_hd__dlygate4sd3_1
Xhold154 memory\[16\]\[6\] VGND VGND VPWR VPWR net363 sky130_fd_sc_hd__dlygate4sd3_1
Xhold176 memory\[27\]\[19\] VGND VGND VPWR VPWR net385 sky130_fd_sc_hd__dlygate4sd3_1
X_4448_ _2109_ VGND VGND VPWR VPWR _0035_ sky130_fd_sc_hd__clkbuf_1
Xhold187 memory\[11\]\[27\] VGND VGND VPWR VPWR net396 sky130_fd_sc_hd__dlygate4sd3_1
Xhold198 memory\[16\]\[20\] VGND VGND VPWR VPWR net407 sky130_fd_sc_hd__dlygate4sd3_1
X_7167_ clknet_leaf_81_clk _0758_ VGND VGND VPWR VPWR memory\[2\]\[16\] sky130_fd_sc_hd__dfxtp_1
X_4379_ _1871_ _2043_ VGND VGND VPWR VPWR _2044_ sky130_fd_sc_hd__or2_1
XTAP_470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6118_ _3094_ VGND VGND VPWR VPWR _3109_ sky130_fd_sc_hd__clkbuf_4
X_7098_ clknet_leaf_98_clk _0689_ VGND VGND VPWR VPWR memory\[29\]\[11\] sky130_fd_sc_hd__dfxtp_1
X_6049_ net1065 _3062_ _3065_ _3069_ VGND VGND VPWR VPWR _1074_ sky130_fd_sc_hd__a31o_1
XFILLER_0_68_404 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_122_715 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_106_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_102_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6834__43 clknet_1_0__leaf__2787_ VGND VGND VPWR VPWR net188 sky130_fd_sc_hd__inv_2
XFILLER_0_86_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3750_ memory\[8\]\[12\] memory\[9\]\[12\] memory\[10\]\[12\] memory\[11\]\[12\]
+ _1202_ _1203_ VGND VGND VPWR VPWR _1444_ sky130_fd_sc_hd__mux4_1
XFILLER_0_55_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_378 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3681_ memory\[28\]\[9\] memory\[29\]\[9\] memory\[30\]\[9\] memory\[31\]\[9\] _1178_
+ _1179_ VGND VGND VPWR VPWR _1378_ sky130_fd_sc_hd__mux4_1
XFILLER_0_112_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5420_ _2463_ _2761_ _2762_ net224 VGND VGND VPWR VPWR _0752_ sky130_fd_sc_hd__a22o_1
X_5351_ _2479_ _2744_ _2745_ net498 VGND VGND VPWR VPWR _0700_ sky130_fd_sc_hd__a22o_1
XFILLER_0_71_9 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_23_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4302_ _1830_ VGND VGND VPWR VPWR _1970_ sky130_fd_sc_hd__buf_8
X_5282_ _2644_ _2708_ VGND VGND VPWR VPWR _2715_ sky130_fd_sc_hd__and2_1
XFILLER_0_49_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7021_ clknet_leaf_16_clk _0612_ VGND VGND VPWR VPWR memory\[26\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_10_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4233_ _1901_ _1902_ _1903_ VGND VGND VPWR VPWR _1904_ sky130_fd_sc_hd__mux2_1
X_4164_ _1832_ VGND VGND VPWR VPWR _1838_ sky130_fd_sc_hd__buf_4
X_4095_ _1168_ _1770_ VGND VGND VPWR VPWR _1771_ sky130_fd_sc_hd__or2_1
XFILLER_0_4_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7923_ net186 _0058_ VGND VGND VPWR VPWR net76 sky130_fd_sc_hd__dfxtp_1
X_7854_ clknet_leaf_40_clk _0388_ VGND VGND VPWR VPWR memory\[9\]\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_77_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7785_ clknet_leaf_35_clk _0319_ VGND VGND VPWR VPWR memory\[30\]\[26\] sky130_fd_sc_hd__dfxtp_1
X_6805_ _2634_ _3441_ _3442_ net838 VGND VGND VPWR VPWR _0432_ sky130_fd_sc_hd__a22o_1
X_4997_ net1164 _2543_ _2540_ VGND VGND VPWR VPWR _2548_ sky130_fd_sc_hd__and3_1
X_6736_ net35 _3414_ VGND VGND VPWR VPWR _3422_ sky130_fd_sc_hd__and2_1
XFILLER_0_58_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_116_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3948_ _1591_ _1631_ _1595_ VGND VGND VPWR VPWR _1632_ sky130_fd_sc_hd__o21a_1
X_6667_ _2671_ _3382_ _3383_ net469 VGND VGND VPWR VPWR _0353_ sky130_fd_sc_hd__a22o_1
XFILLER_0_73_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_61_635 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3879_ _1566_ VGND VGND VPWR VPWR _0009_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_46_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5618_ net728 _2811_ _2816_ _2820_ VGND VGND VPWR VPWR _0860_ sky130_fd_sc_hd__a31o_1
XFILLER_0_103_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6598_ _2617_ _3368_ _3370_ net845 VGND VGND VPWR VPWR _0297_ sky130_fd_sc_hd__a22o_1
X_5549_ clknet_1_1__leaf__2783_ VGND VGND VPWR VPWR _2786_ sky130_fd_sc_hd__buf_1
XFILLER_0_60_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7219_ clknet_leaf_4_clk _0810_ VGND VGND VPWR VPWR memory\[31\]\[4\] sky130_fd_sc_hd__dfxtp_1
XTAP_1433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_122_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_24_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_86_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_20_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_510 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4920_ _2485_ _2499_ _2500_ net370 VGND VGND VPWR VPWR _0513_ sky130_fd_sc_hd__a22o_1
XFILLER_0_59_245 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_87_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_289 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4851_ _2473_ _2464_ _2465_ net321 VGND VGND VPWR VPWR _0471_ sky130_fd_sc_hd__a22o_1
X_3802_ memory\[16\]\[15\] memory\[17\]\[15\] memory\[18\]\[15\] memory\[19\]\[15\]
+ _1349_ _1350_ VGND VGND VPWR VPWR _1493_ sky130_fd_sc_hd__mux4_1
X_4782_ memory\[24\]\[31\] memory\[25\]\[31\] memory\[26\]\[31\] memory\[27\]\[31\]
+ _1821_ _1822_ VGND VGND VPWR VPWR _2425_ sky130_fd_sc_hd__mux4_1
X_7570_ clknet_leaf_115_clk _1129_ VGND VGND VPWR VPWR memory\[23\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_51_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3733_ memory\[8\]\[11\] memory\[9\]\[11\] memory\[10\]\[11\] memory\[11\]\[11\]
+ _1426_ _1427_ VGND VGND VPWR VPWR _1428_ sky130_fd_sc_hd__mux4_1
X_6521_ net1060 _3317_ _3324_ _3328_ VGND VGND VPWR VPWR _0262_ sky130_fd_sc_hd__a31o_1
X_6452_ _2847_ _3282_ VGND VGND VPWR VPWR _3288_ sky130_fd_sc_hd__and2_1
XFILLER_0_3_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3664_ memory\[4\]\[8\] memory\[5\]\[8\] memory\[6\]\[8\] memory\[7\]\[8\] _1360_
+ _1361_ VGND VGND VPWR VPWR _1362_ sky130_fd_sc_hd__mux4_1
X_5403_ _2746_ _2442_ _2501_ VGND VGND VPWR VPWR _2756_ sky130_fd_sc_hd__and3_1
X_5561__35 clknet_1_1__leaf__2787_ VGND VGND VPWR VPWR net180 sky130_fd_sc_hd__inv_2
X_6383_ net537 _3233_ _3236_ _3247_ VGND VGND VPWR VPWR _0205_ sky130_fd_sc_hd__a31o_1
XFILLER_0_2_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3595_ memory\[16\]\[5\] memory\[17\]\[5\] memory\[18\]\[5\] memory\[19\]\[5\] _1161_
+ _1162_ VGND VGND VPWR VPWR _1296_ sky130_fd_sc_hd__mux4_1
XFILLER_0_100_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5334_ _2462_ _2739_ _2741_ net266 VGND VGND VPWR VPWR _0687_ sky130_fd_sc_hd__a22o_1
X_5265_ net764 _2704_ _2693_ _2705_ VGND VGND VPWR VPWR _0654_ sky130_fd_sc_hd__a31o_1
X_5196_ net40 VGND VGND VPWR VPWR _2678_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_76_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7004_ clknet_leaf_93_clk _0595_ VGND VGND VPWR VPWR memory\[26\]\[13\] sky130_fd_sc_hd__dfxtp_1
X_4216_ _1812_ _1887_ VGND VGND VPWR VPWR _1888_ sky130_fd_sc_hd__or2_1
XFILLER_0_48_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4147_ _1813_ VGND VGND VPWR VPWR _1821_ sky130_fd_sc_hd__buf_6
X_4078_ _1753_ _1754_ _1521_ VGND VGND VPWR VPWR _1755_ sky130_fd_sc_hd__mux2_1
X_7906_ clknet_leaf_98_clk _0440_ VGND VGND VPWR VPWR memory\[17\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_65_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7837_ clknet_leaf_80_clk _0371_ VGND VGND VPWR VPWR memory\[9\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_93_546 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_19_632 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_65_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7768_ clknet_leaf_5_clk _0302_ VGND VGND VPWR VPWR memory\[30\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_80_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6719_ net1074 _3406_ _3400_ _3412_ VGND VGND VPWR VPWR _0376_ sky130_fd_sc_hd__a31o_1
X_7699_ clknet_leaf_110_clk _0233_ VGND VGND VPWR VPWR memory\[5\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_18_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_61_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_104_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_14_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold709 memory\[26\]\[6\] VGND VGND VPWR VPWR net918 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_110_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5050_ _2470_ _2571_ _2579_ VGND VGND VPWR VPWR _0565_ sky130_fd_sc_hd__a21o_1
X_4001_ memory\[28\]\[25\] memory\[29\]\[25\] memory\[30\]\[25\] memory\[31\]\[25\]
+ _1592_ _1593_ VGND VGND VPWR VPWR _1682_ sky130_fd_sc_hd__mux4_1
XFILLER_0_34_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5952_ _2842_ _3010_ VGND VGND VPWR VPWR _3014_ sky130_fd_sc_hd__and2_1
X_4903_ _2468_ _2497_ _2498_ net457 VGND VGND VPWR VPWR _0498_ sky130_fd_sc_hd__a22o_1
XFILLER_0_62_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5883_ net635 _2968_ _2963_ _2973_ VGND VGND VPWR VPWR _1004_ sky130_fd_sc_hd__a31o_1
XFILLER_0_118_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7622_ clknet_leaf_30_clk _0156_ VGND VGND VPWR VPWR memory\[27\]\[23\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_75_579 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_75_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4834_ _2452_ VGND VGND VPWR VPWR _2465_ sky130_fd_sc_hd__clkbuf_4
X_4765_ _1959_ _2408_ VGND VGND VPWR VPWR _2409_ sky130_fd_sc_hd__or2_1
XFILLER_0_16_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7553_ clknet_leaf_96_clk _1112_ VGND VGND VPWR VPWR memory\[20\]\[18\] sky130_fd_sc_hd__dfxtp_1
X_3716_ net10 VGND VGND VPWR VPWR _1412_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_16_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6504_ _2508_ VGND VGND VPWR VPWR _3317_ sky130_fd_sc_hd__buf_8
X_4696_ _2338_ _2340_ _2343_ _1862_ _2223_ VGND VGND VPWR VPWR _2344_ sky130_fd_sc_hd__a221o_1
X_7484_ clknet_leaf_97_clk _1043_ VGND VGND VPWR VPWR memory\[24\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_113_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6435_ _2905_ _3237_ VGND VGND VPWR VPWR _3277_ sky130_fd_sc_hd__and2_1
X_3647_ _1236_ _1341_ _1343_ _1345_ _1208_ VGND VGND VPWR VPWR _1346_ sky130_fd_sc_hd__a221o_1
X_6366_ _2834_ _3238_ VGND VGND VPWR VPWR _3239_ sky130_fd_sc_hd__and2_1
X_3578_ _1277_ _1278_ _1279_ VGND VGND VPWR VPWR _1280_ sky130_fd_sc_hd__mux2_1
X_5317_ _2678_ _2694_ VGND VGND VPWR VPWR _2735_ sky130_fd_sc_hd__and2_1
Xhold14 memory\[14\]\[21\] VGND VGND VPWR VPWR net223 sky130_fd_sc_hd__dlygate4sd3_1
X_6297_ net997 _3200_ _3209_ _3212_ VGND VGND VPWR VPWR _0154_ sky130_fd_sc_hd__a31o_1
Xhold36 memory\[3\]\[26\] VGND VGND VPWR VPWR net245 sky130_fd_sc_hd__dlygate4sd3_1
Xhold25 memory\[15\]\[19\] VGND VGND VPWR VPWR net234 sky130_fd_sc_hd__dlygate4sd3_1
Xhold47 memory\[19\]\[31\] VGND VGND VPWR VPWR net256 sky130_fd_sc_hd__dlygate4sd3_1
X_5248_ net1016 _2675_ _2693_ _2696_ VGND VGND VPWR VPWR _0646_ sky130_fd_sc_hd__a31o_1
X_5179_ net970 _2652_ _2653_ _2666_ VGND VGND VPWR VPWR _0607_ sky130_fd_sc_hd__a31o_1
Xhold58 memory\[19\]\[26\] VGND VGND VPWR VPWR net267 sky130_fd_sc_hd__dlygate4sd3_1
Xhold69 memory\[3\]\[6\] VGND VGND VPWR VPWR net278 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_81_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_527 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_34_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5540__16 clknet_1_1__leaf__2785_ VGND VGND VPWR VPWR net161 sky130_fd_sc_hd__inv_2
XFILLER_0_107_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_88_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_97_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_96_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1082 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1071 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1060 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1093 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_106_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_25_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4550_ _2086_ _2201_ _2203_ _2205_ _2038_ VGND VGND VPWR VPWR _2206_ sky130_fd_sc_hd__a221o_1
XFILLER_0_52_240 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold506 memory\[12\]\[16\] VGND VGND VPWR VPWR net715 sky130_fd_sc_hd__dlygate4sd3_1
X_3501_ _1154_ VGND VGND VPWR VPWR _1207_ sky130_fd_sc_hd__clkbuf_8
Xhold517 memory\[13\]\[11\] VGND VGND VPWR VPWR net726 sky130_fd_sc_hd__dlygate4sd3_1
X_4481_ memory\[8\]\[14\] memory\[9\]\[14\] memory\[10\]\[14\] memory\[11\]\[14\]
+ _1913_ _1914_ VGND VGND VPWR VPWR _2141_ sky130_fd_sc_hd__mux4_1
Xhold528 memory\[17\]\[23\] VGND VGND VPWR VPWR net737 sky130_fd_sc_hd__dlygate4sd3_1
X_6220_ net414 _3159_ _3166_ _3168_ VGND VGND VPWR VPWR _1146_ sky130_fd_sc_hd__a31o_1
Xhold539 memory\[15\]\[12\] VGND VGND VPWR VPWR net748 sky130_fd_sc_hd__dlygate4sd3_1
X_6151_ _2891_ _3123_ VGND VGND VPWR VPWR _3128_ sky130_fd_sc_hd__and2_1
XTAP_800 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_811 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5102_ net38 VGND VGND VPWR VPWR _2613_ sky130_fd_sc_hd__buf_4
XTAP_822 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_833 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_844 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6082_ net396 _3075_ _3078_ _3087_ VGND VGND VPWR VPWR _1089_ sky130_fd_sc_hd__a31o_1
XTAP_855 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_877 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_866 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5033_ _2461_ _2556_ _2569_ VGND VGND VPWR VPWR _0558_ sky130_fd_sc_hd__a21o_1
XTAP_888 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_899 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6984_ clknet_leaf_48_clk _0575_ VGND VGND VPWR VPWR memory\[6\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_79_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5935_ net810 _2994_ _2990_ _3002_ VGND VGND VPWR VPWR _1027_ sky130_fd_sc_hd__a31o_1
XFILLER_0_8_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5866_ _2962_ VGND VGND VPWR VPWR _2963_ sky130_fd_sc_hd__clkbuf_4
Xclkbuf_leaf_60_clk clknet_4_15_0_clk VGND VGND VPWR VPWR clknet_leaf_60_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_90_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_75_376 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_7605_ clknet_leaf_9_clk _0139_ VGND VGND VPWR VPWR memory\[27\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_4817_ _2455_ _2449_ _2453_ net211 VGND VGND VPWR VPWR _0455_ sky130_fd_sc_hd__a22o_1
X_5797_ net1172 _2597_ _2921_ VGND VGND VPWR VPWR _2924_ sky130_fd_sc_hd__and3_1
X_4748_ memory\[16\]\[29\] memory\[17\]\[29\] memory\[18\]\[29\] memory\[19\]\[29\]
+ _1970_ _1971_ VGND VGND VPWR VPWR _2393_ sky130_fd_sc_hd__mux4_1
X_7536_ clknet_leaf_114_clk _1095_ VGND VGND VPWR VPWR memory\[20\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_16_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4679_ memory\[8\]\[25\] memory\[9\]\[25\] memory\[10\]\[25\] memory\[11\]\[25\]
+ _1948_ _1949_ VGND VGND VPWR VPWR _2328_ sky130_fd_sc_hd__mux4_1
X_7467_ clknet_leaf_64_clk _1026_ VGND VGND VPWR VPWR memory\[1\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_101_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6418_ _2888_ _3264_ VGND VGND VPWR VPWR _3268_ sky130_fd_sc_hd__and2_1
XFILLER_0_31_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7398_ clknet_leaf_31_clk _0957_ VGND VGND VPWR VPWR memory\[25\]\[23\] sky130_fd_sc_hd__dfxtp_1
X_6349_ _2657_ _3231_ _3232_ net308 VGND VGND VPWR VPWR _0186_ sky130_fd_sc_hd__a22o_1
XFILLER_0_12_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput59 net59 VGND VGND VPWR VPWR data_out1[18] sky130_fd_sc_hd__buf_2
XFILLER_0_86_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_94_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_51_clk clknet_4_14_0_clk VGND VGND VPWR VPWR clknet_leaf_51_clk sky130_fd_sc_hd__clkbuf_16
XPHY_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_105_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_468 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3981_ memory\[24\]\[24\] memory\[25\]\[24\] memory\[26\]\[24\] memory\[27\]\[24\]
+ _1551_ _1552_ VGND VGND VPWR VPWR _1663_ sky130_fd_sc_hd__mux4_1
XPHY_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5720_ net973 _2867_ _2880_ _2889_ VGND VGND VPWR VPWR _0893_ sky130_fd_sc_hd__a31o_1
Xclkbuf_leaf_42_clk clknet_4_9_0_clk VGND VGND VPWR VPWR clknet_leaf_42_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_45_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5651_ net803 _2824_ _2833_ _2841_ VGND VGND VPWR VPWR _0872_ sky130_fd_sc_hd__a31o_1
X_4602_ memory\[24\]\[21\] memory\[25\]\[21\] memory\[26\]\[21\] memory\[27\]\[21\]
+ _2032_ _2033_ VGND VGND VPWR VPWR _2255_ sky130_fd_sc_hd__mux4_1
X_5582_ _2623_ _2791_ VGND VGND VPWR VPWR _2800_ sky130_fd_sc_hd__and2_1
X_4533_ memory\[0\]\[17\] memory\[1\]\[17\] memory\[2\]\[17\] memory\[3\]\[17\] _2017_
+ _2018_ VGND VGND VPWR VPWR _2190_ sky130_fd_sc_hd__mux4_1
X_7321_ clknet_leaf_85_clk _0880_ VGND VGND VPWR VPWR memory\[7\]\[10\] sky130_fd_sc_hd__dfxtp_1
Xhold303 memory\[30\]\[25\] VGND VGND VPWR VPWR net512 sky130_fd_sc_hd__dlygate4sd3_1
Xhold314 memory\[5\]\[25\] VGND VGND VPWR VPWR net523 sky130_fd_sc_hd__dlygate4sd3_1
Xhold325 memory\[5\]\[13\] VGND VGND VPWR VPWR net534 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7252_ net155 _0027_ VGND VGND VPWR VPWR net109 sky130_fd_sc_hd__dfxtp_2
Xhold369 memory\[11\]\[24\] VGND VGND VPWR VPWR net578 sky130_fd_sc_hd__dlygate4sd3_1
Xhold347 memory\[12\]\[5\] VGND VGND VPWR VPWR net556 sky130_fd_sc_hd__dlygate4sd3_1
X_6203_ net1032 _3146_ _3153_ _3158_ VGND VGND VPWR VPWR _1139_ sky130_fd_sc_hd__a31o_1
XFILLER_0_7_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4464_ memory\[4\]\[13\] memory\[5\]\[13\] memory\[6\]\[13\] memory\[7\]\[13\] _1842_
+ _1843_ VGND VGND VPWR VPWR _2125_ sky130_fd_sc_hd__mux4_1
Xhold358 memory\[30\]\[10\] VGND VGND VPWR VPWR net567 sky130_fd_sc_hd__dlygate4sd3_1
Xhold336 memory\[28\]\[0\] VGND VGND VPWR VPWR net545 sky130_fd_sc_hd__dlygate4sd3_1
X_7183_ clknet_leaf_21_clk _0774_ VGND VGND VPWR VPWR memory\[14\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_4395_ memory\[8\]\[10\] memory\[9\]\[10\] memory\[10\]\[10\] memory\[11\]\[10\]
+ _1948_ _1949_ VGND VGND VPWR VPWR _2059_ sky130_fd_sc_hd__mux4_1
XFILLER_0_110_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6134_ net630 _3117_ _3109_ _3118_ VGND VGND VPWR VPWR _1110_ sky130_fd_sc_hd__a31o_1
XTAP_630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6065_ _3050_ VGND VGND VPWR VPWR _3078_ sky130_fd_sc_hd__clkbuf_4
XTAP_663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5016_ memory\[6\]\[0\] _2557_ _2560_ VGND VGND VPWR VPWR _2561_ sky130_fd_sc_hd__and3_1
XFILLER_0_30_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1807 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1829 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1818 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6967_ clknet_leaf_107_clk _0558_ VGND VGND VPWR VPWR memory\[6\]\[8\] sky130_fd_sc_hd__dfxtp_1
X_5918_ net1008 _2981_ _2990_ _2993_ VGND VGND VPWR VPWR _1019_ sky130_fd_sc_hd__a31o_1
Xclkbuf_leaf_33_clk clknet_4_10_0_clk VGND VGND VPWR VPWR clknet_leaf_33_clk sky130_fd_sc_hd__clkbuf_16
X_6898_ clknet_leaf_22_clk _0489_ VGND VGND VPWR VPWR memory\[15\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_5849_ memory\[25\]\[25\] _2943_ _2947_ VGND VGND VPWR VPWR _2953_ sky130_fd_sc_hd__and3_1
XFILLER_0_8_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7519_ clknet_leaf_80_clk _1078_ VGND VGND VPWR VPWR memory\[11\]\[16\] sky130_fd_sc_hd__dfxtp_1
Xhold881 memory\[21\]\[23\] VGND VGND VPWR VPWR net1090 sky130_fd_sc_hd__dlygate4sd3_1
Xhold870 memory\[26\]\[13\] VGND VGND VPWR VPWR net1079 sky130_fd_sc_hd__dlygate4sd3_1
Xhold892 memory\[26\]\[31\] VGND VGND VPWR VPWR net1101 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_98_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_24_clk clknet_4_8_0_clk VGND VGND VPWR VPWR clknet_leaf_24_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_27_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_54_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_120_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4180_ _1853_ VGND VGND VPWR VPWR _0032_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_89_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7870_ clknet_leaf_68_clk _0404_ VGND VGND VPWR VPWR memory\[13\]\[15\] sky130_fd_sc_hd__dfxtp_1
X_6821_ _2665_ _3443_ _3444_ net1036 VGND VGND VPWR VPWR _0446_ sky130_fd_sc_hd__a22o_1
XFILLER_0_54_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3964_ _1588_ _1646_ VGND VGND VPWR VPWR _1647_ sky130_fd_sc_hd__or2_1
X_6752_ _2611_ _3429_ _3431_ net603 VGND VGND VPWR VPWR _0390_ sky130_fd_sc_hd__a22o_1
Xclkbuf_leaf_15_clk clknet_4_9_0_clk VGND VGND VPWR VPWR clknet_leaf_15_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_57_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_116_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6683_ net929 _3359_ _3386_ _3392_ VGND VGND VPWR VPWR _0360_ sky130_fd_sc_hd__a31o_1
X_3895_ _1479_ _1577_ _1579_ _1581_ _1412_ VGND VGND VPWR VPWR _1582_ sky130_fd_sc_hd__a221o_1
XFILLER_0_57_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5703_ net1006 _2867_ _2857_ _2877_ VGND VGND VPWR VPWR _0888_ sky130_fd_sc_hd__a31o_1
X_5634_ _2676_ _2790_ VGND VGND VPWR VPWR _2829_ sky130_fd_sc_hd__and2_1
XFILLER_0_26_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7304_ clknet_leaf_55_clk _0863_ VGND VGND VPWR VPWR memory\[8\]\[25\] sky130_fd_sc_hd__dfxtp_1
X_5565_ _2440_ _2441_ _2690_ _2511_ VGND VGND VPWR VPWR _2790_ sky130_fd_sc_hd__and4_2
XFILLER_0_78_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_5_476 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold100 memory\[2\]\[4\] VGND VGND VPWR VPWR net309 sky130_fd_sc_hd__dlygate4sd3_1
Xhold133 memory\[15\]\[26\] VGND VGND VPWR VPWR net342 sky130_fd_sc_hd__dlygate4sd3_1
X_4516_ memory\[12\]\[16\] memory\[13\]\[16\] memory\[14\]\[16\] memory\[15\]\[16\]
+ _1973_ _1974_ VGND VGND VPWR VPWR _2174_ sky130_fd_sc_hd__mux4_1
Xhold144 memory\[9\]\[17\] VGND VGND VPWR VPWR net353 sky130_fd_sc_hd__dlygate4sd3_1
X_5496_ _2621_ _2776_ _2778_ net746 VGND VGND VPWR VPWR _0812_ sky130_fd_sc_hd__a22o_1
Xhold122 memory\[24\]\[8\] VGND VGND VPWR VPWR net331 sky130_fd_sc_hd__dlygate4sd3_1
Xhold111 memory\[3\]\[11\] VGND VGND VPWR VPWR net320 sky130_fd_sc_hd__dlygate4sd3_1
Xhold177 memory\[29\]\[24\] VGND VGND VPWR VPWR net386 sky130_fd_sc_hd__dlygate4sd3_1
X_7235_ clknet_leaf_36_clk _0826_ VGND VGND VPWR VPWR memory\[31\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_1_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold155 memory\[28\]\[12\] VGND VGND VPWR VPWR net364 sky130_fd_sc_hd__dlygate4sd3_1
X_4447_ _2096_ _2108_ VGND VGND VPWR VPWR _2109_ sky130_fd_sc_hd__and2_1
Xhold166 memory\[2\]\[12\] VGND VGND VPWR VPWR net375 sky130_fd_sc_hd__dlygate4sd3_1
Xhold188 memory\[3\]\[31\] VGND VGND VPWR VPWR net397 sky130_fd_sc_hd__dlygate4sd3_1
Xhold199 memory\[14\]\[2\] VGND VGND VPWR VPWR net408 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_7166_ clknet_leaf_83_clk _0757_ VGND VGND VPWR VPWR memory\[2\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_95_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4378_ memory\[8\]\[9\] memory\[9\]\[9\] memory\[10\]\[9\] memory\[11\]\[9\] _1913_
+ _1914_ VGND VGND VPWR VPWR _2043_ sky130_fd_sc_hd__mux4_1
X_6117_ net1058 _3104_ _3095_ _3108_ VGND VGND VPWR VPWR _1103_ sky130_fd_sc_hd__a31o_1
XTAP_460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7097_ clknet_leaf_77_clk _0688_ VGND VGND VPWR VPWR memory\[29\]\[10\] sky130_fd_sc_hd__dfxtp_1
X_6048_ _2863_ _3066_ VGND VGND VPWR VPWR _3069_ sky130_fd_sc_hd__and2_1
XTAP_1615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_119_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_154 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_36_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_91_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_115_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_24_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3680_ _1169_ _1376_ VGND VGND VPWR VPWR _1377_ sky130_fd_sc_hd__or2_1
XFILLER_0_113_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5350_ _2478_ _2744_ _2745_ net274 VGND VGND VPWR VPWR _0699_ sky130_fd_sc_hd__a22o_1
XFILLER_0_49_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5281_ net646 _2704_ _2707_ _2714_ VGND VGND VPWR VPWR _0661_ sky130_fd_sc_hd__a31o_1
X_4301_ _1964_ _1967_ _1968_ VGND VGND VPWR VPWR _1969_ sky130_fd_sc_hd__o21a_1
X_7020_ clknet_leaf_32_clk _0611_ VGND VGND VPWR VPWR memory\[26\]\[29\] sky130_fd_sc_hd__dfxtp_1
X_4232_ _1808_ VGND VGND VPWR VPWR _1903_ sky130_fd_sc_hd__buf_4
Xclkbuf_leaf_4_clk clknet_4_2_0_clk VGND VGND VPWR VPWR clknet_leaf_4_clk sky130_fd_sc_hd__clkbuf_16
X_4163_ _1830_ VGND VGND VPWR VPWR _1837_ sky130_fd_sc_hd__clkbuf_8
X_4094_ memory\[8\]\[30\] memory\[9\]\[30\] memory\[10\]\[30\] memory\[11\]\[30\]
+ _1202_ _1203_ VGND VGND VPWR VPWR _1770_ sky130_fd_sc_hd__mux4_1
X_7922_ net185 _0057_ VGND VGND VPWR VPWR net75 sky130_fd_sc_hd__dfxtp_1
X_7853_ clknet_leaf_41_clk _0387_ VGND VGND VPWR VPWR memory\[9\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_77_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7784_ clknet_leaf_36_clk _0318_ VGND VGND VPWR VPWR memory\[30\]\[25\] sky130_fd_sc_hd__dfxtp_1
X_4996_ _2482_ _2539_ _2547_ VGND VGND VPWR VPWR _0543_ sky130_fd_sc_hd__a21o_1
XFILLER_0_81_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6804_ _2631_ _3441_ _3442_ net217 VGND VGND VPWR VPWR _0431_ sky130_fd_sc_hd__a22o_1
X_6735_ net686 _2509_ _3413_ _3421_ VGND VGND VPWR VPWR _0383_ sky130_fd_sc_hd__a31o_1
X_3947_ memory\[28\]\[22\] memory\[29\]\[22\] memory\[30\]\[22\] memory\[31\]\[22\]
+ _1592_ _1593_ VGND VGND VPWR VPWR _1631_ sky130_fd_sc_hd__mux4_1
XFILLER_0_45_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6666_ _2669_ _3382_ _3383_ net304 VGND VGND VPWR VPWR _0352_ sky130_fd_sc_hd__a22o_1
XFILLER_0_61_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3878_ _1557_ _1565_ VGND VGND VPWR VPWR _1566_ sky130_fd_sc_hd__and2_1
XFILLER_0_116_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5617_ _2659_ _2817_ VGND VGND VPWR VPWR _2820_ sky130_fd_sc_hd__and2_1
XFILLER_0_61_647 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6597_ _2615_ _3368_ _3370_ net676 VGND VGND VPWR VPWR _0296_ sky130_fd_sc_hd__a22o_1
XFILLER_0_41_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5479_ _2483_ _2772_ _2773_ net472 VGND VGND VPWR VPWR _0800_ sky130_fd_sc_hd__a22o_1
X_7218_ clknet_leaf_5_clk _0809_ VGND VGND VPWR VPWR memory\[31\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_7149_ clknet_leaf_46_clk _0740_ VGND VGND VPWR VPWR memory\[3\]\[30\] sky130_fd_sc_hd__dfxtp_1
XTAP_290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_69_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_1423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_101_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_122_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_102_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_522 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_87_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_99_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_59_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4850_ net25 VGND VGND VPWR VPWR _2473_ sky130_fd_sc_hd__buf_4
XFILLER_0_74_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3801_ memory\[20\]\[15\] memory\[21\]\[15\] memory\[22\]\[15\] memory\[23\]\[15\]
+ _1312_ _1313_ VGND VGND VPWR VPWR _1492_ sky130_fd_sc_hd__mux4_1
X_4781_ _2422_ _2423_ _1809_ VGND VGND VPWR VPWR _2424_ sky130_fd_sc_hd__mux2_1
XFILLER_0_55_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6520_ _2838_ _3326_ VGND VGND VPWR VPWR _3328_ sky130_fd_sc_hd__and2_1
X_3732_ _1189_ VGND VGND VPWR VPWR _1427_ sky130_fd_sc_hd__buf_4
X_5546__22 clknet_1_1__leaf__2785_ VGND VGND VPWR VPWR net167 sky130_fd_sc_hd__inv_2
XFILLER_0_28_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6451_ net1083 _3275_ _3280_ _3287_ VGND VGND VPWR VPWR _0233_ sky130_fd_sc_hd__a31o_1
X_3663_ net7 VGND VGND VPWR VPWR _1361_ sky130_fd_sc_hd__buf_4
X_5402_ _2488_ _2748_ _2750_ net397 VGND VGND VPWR VPWR _0741_ sky130_fd_sc_hd__a22o_1
XFILLER_0_70_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6382_ _2853_ _3238_ VGND VGND VPWR VPWR _3247_ sky130_fd_sc_hd__and2_1
X_5333_ _2461_ _2739_ _2741_ net693 VGND VGND VPWR VPWR _0686_ sky130_fd_sc_hd__a22o_1
X_3594_ memory\[20\]\[5\] memory\[21\]\[5\] memory\[22\]\[5\] memory\[23\]\[5\] _1157_
+ _1159_ VGND VGND VPWR VPWR _1295_ sky130_fd_sc_hd__mux4_1
XFILLER_0_51_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_287 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_76_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5264_ _2625_ _2695_ VGND VGND VPWR VPWR _2705_ sky130_fd_sc_hd__and2_1
XFILLER_0_76_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5195_ net460 _2675_ _2605_ _2677_ VGND VGND VPWR VPWR _0612_ sky130_fd_sc_hd__a31o_1
X_7003_ clknet_leaf_93_clk _0594_ VGND VGND VPWR VPWR memory\[26\]\[12\] sky130_fd_sc_hd__dfxtp_1
X_4215_ memory\[24\]\[2\] memory\[25\]\[2\] memory\[26\]\[2\] memory\[27\]\[2\] _1814_
+ _1816_ VGND VGND VPWR VPWR _1887_ sky130_fd_sc_hd__mux4_1
X_4146_ _1819_ VGND VGND VPWR VPWR _1820_ sky130_fd_sc_hd__buf_4
X_4077_ memory\[0\]\[29\] memory\[1\]\[29\] memory\[2\]\[29\] memory\[3\]\[29\] _1237_
+ _1238_ VGND VGND VPWR VPWR _1754_ sky130_fd_sc_hd__mux4_1
X_7905_ clknet_leaf_91_clk _0439_ VGND VGND VPWR VPWR memory\[17\]\[18\] sky130_fd_sc_hd__dfxtp_1
X_7836_ clknet_leaf_70_clk _0370_ VGND VGND VPWR VPWR memory\[9\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_93_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4979_ _2473_ _2525_ _2537_ VGND VGND VPWR VPWR _0536_ sky130_fd_sc_hd__a21o_1
XFILLER_0_19_644 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_7767_ clknet_leaf_7_clk _0301_ VGND VGND VPWR VPWR memory\[30\]\[8\] sky130_fd_sc_hd__dfxtp_1
X_6718_ net26 _3401_ VGND VGND VPWR VPWR _3412_ sky130_fd_sc_hd__and2_1
X_7698_ clknet_leaf_109_clk _0232_ VGND VGND VPWR VPWR memory\[5\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_33_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6649_ _2636_ _3380_ _3381_ net756 VGND VGND VPWR VPWR _0337_ sky130_fd_sc_hd__a22o_1
XFILLER_0_33_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_1297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_112_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_122_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_107_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_122_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7438__114 VGND VGND VPWR VPWR _7438__114/HI net114 sky130_fd_sc_hd__conb_1
X_4000_ _1588_ _1680_ VGND VGND VPWR VPWR _1681_ sky130_fd_sc_hd__or2_1
X_5951_ net427 _3006_ _3008_ _3013_ VGND VGND VPWR VPWR _1032_ sky130_fd_sc_hd__a31o_1
XFILLER_0_75_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4902_ _2467_ _2497_ _2498_ net748 VGND VGND VPWR VPWR _0497_ sky130_fd_sc_hd__a22o_1
XFILLER_0_1_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5882_ _2849_ _2965_ VGND VGND VPWR VPWR _2973_ sky130_fd_sc_hd__and2_1
X_7621_ clknet_leaf_29_clk _0155_ VGND VGND VPWR VPWR memory\[27\]\[22\] sky130_fd_sc_hd__dfxtp_1
X_4833_ _2448_ VGND VGND VPWR VPWR _2464_ sky130_fd_sc_hd__clkbuf_4
X_4764_ memory\[24\]\[30\] memory\[25\]\[30\] memory\[26\]\[30\] memory\[27\]\[30\]
+ _1877_ _1878_ VGND VGND VPWR VPWR _2408_ sky130_fd_sc_hd__mux4_1
XFILLER_0_7_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7552_ clknet_leaf_106_clk _1111_ VGND VGND VPWR VPWR memory\[20\]\[17\] sky130_fd_sc_hd__dfxtp_1
X_6503_ net993 _3304_ _3307_ _3316_ VGND VGND VPWR VPWR _0256_ sky130_fd_sc_hd__a31o_1
X_3715_ _1250_ _1410_ _1254_ VGND VGND VPWR VPWR _1411_ sky130_fd_sc_hd__o21a_1
XFILLER_0_7_379 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_15_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7483_ clknet_leaf_97_clk _1042_ VGND VGND VPWR VPWR memory\[24\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_113_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4695_ _2341_ _2342_ _1848_ VGND VGND VPWR VPWR _2343_ sky130_fd_sc_hd__mux2_1
XFILLER_0_16_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6434_ net1075 _3275_ _3235_ _3276_ VGND VGND VPWR VPWR _0227_ sky130_fd_sc_hd__a31o_1
XFILLER_0_102_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3646_ _1250_ _1344_ _1254_ VGND VGND VPWR VPWR _1345_ sky130_fd_sc_hd__o21a_1
XFILLER_0_3_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_30_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_113_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_3_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6365_ _3237_ VGND VGND VPWR VPWR _3238_ sky130_fd_sc_hd__buf_2
X_3577_ _1165_ VGND VGND VPWR VPWR _1279_ sky130_fd_sc_hd__clkbuf_8
X_6296_ _2884_ _3210_ VGND VGND VPWR VPWR _3212_ sky130_fd_sc_hd__and2_1
X_5316_ net504 _2731_ _2692_ _2734_ VGND VGND VPWR VPWR _0676_ sky130_fd_sc_hd__a31o_1
X_5247_ _2607_ _2695_ VGND VGND VPWR VPWR _2696_ sky130_fd_sc_hd__and2_1
Xhold26 memory\[13\]\[23\] VGND VGND VPWR VPWR net235 sky130_fd_sc_hd__dlygate4sd3_1
Xhold37 memory\[14\]\[22\] VGND VGND VPWR VPWR net246 sky130_fd_sc_hd__dlygate4sd3_1
Xhold15 memory\[2\]\[10\] VGND VGND VPWR VPWR net224 sky130_fd_sc_hd__dlygate4sd3_1
X_5178_ _2665_ _2655_ VGND VGND VPWR VPWR _2666_ sky130_fd_sc_hd__and2_1
Xhold59 memory\[1\]\[30\] VGND VGND VPWR VPWR net268 sky130_fd_sc_hd__dlygate4sd3_1
Xhold48 memory\[1\]\[10\] VGND VGND VPWR VPWR net257 sky130_fd_sc_hd__dlygate4sd3_1
X_4129_ memory\[20\]\[0\] memory\[21\]\[0\] memory\[22\]\[0\] memory\[23\]\[0\] _1800_
+ _1802_ VGND VGND VPWR VPWR _1803_ sky130_fd_sc_hd__mux4_1
XFILLER_0_97_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_109_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_78_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7819_ clknet_leaf_52_clk _0353_ VGND VGND VPWR VPWR memory\[12\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_93_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_539 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_104_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_672 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_107_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_89_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1083 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1072 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1061 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1050 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_547 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_32_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_84_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1094 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_107_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_13_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3500_ _1201_ _1204_ _1205_ VGND VGND VPWR VPWR _1206_ sky130_fd_sc_hd__mux2_1
Xhold518 memory\[20\]\[10\] VGND VGND VPWR VPWR net727 sky130_fd_sc_hd__dlygate4sd3_1
Xhold507 memory\[26\]\[17\] VGND VGND VPWR VPWR net716 sky130_fd_sc_hd__dlygate4sd3_1
X_4480_ _2138_ _2139_ _1869_ VGND VGND VPWR VPWR _2140_ sky130_fd_sc_hd__mux2_1
XFILLER_0_52_285 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold529 memory\[18\]\[0\] VGND VGND VPWR VPWR net738 sky130_fd_sc_hd__dlygate4sd3_1
X_6150_ net692 _3117_ _3122_ _3127_ VGND VGND VPWR VPWR _1117_ sky130_fd_sc_hd__a31o_1
XFILLER_0_0_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_801 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_182 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5101_ net992 _2601_ _2606_ _2612_ VGND VGND VPWR VPWR _0583_ sky130_fd_sc_hd__a31o_1
XTAP_812 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_823 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_834 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6081_ _2897_ _3079_ VGND VGND VPWR VPWR _3087_ sky130_fd_sc_hd__and2_1
XTAP_845 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_856 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_867 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5032_ memory\[6\]\[8\] _2557_ _2560_ VGND VGND VPWR VPWR _2569_ sky130_fd_sc_hd__and3_1
XTAP_878 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_889 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6983_ clknet_leaf_56_clk _0574_ VGND VGND VPWR VPWR memory\[6\]\[24\] sky130_fd_sc_hd__dfxtp_1
X_5934_ _2901_ _2991_ VGND VGND VPWR VPWR _3002_ sky130_fd_sc_hd__and2_1
X_5865_ _2961_ VGND VGND VPWR VPWR _2962_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_75_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7604_ clknet_leaf_0_clk _0138_ VGND VGND VPWR VPWR memory\[27\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_4816_ net38 VGND VGND VPWR VPWR _2455_ sky130_fd_sc_hd__buf_4
XFILLER_0_90_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5796_ _2454_ _2919_ _2923_ VGND VGND VPWR VPWR _0935_ sky130_fd_sc_hd__a21o_1
X_4747_ memory\[20\]\[29\] memory\[21\]\[29\] memory\[22\]\[29\] memory\[23\]\[29\]
+ _1831_ _1833_ VGND VGND VPWR VPWR _2392_ sky130_fd_sc_hd__mux4_1
XFILLER_0_8_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7535_ clknet_leaf_114_clk _1094_ VGND VGND VPWR VPWR memory\[20\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_16_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4678_ _2086_ _2322_ _2324_ _2326_ _2223_ VGND VGND VPWR VPWR _2327_ sky130_fd_sc_hd__a221o_1
X_7466_ clknet_leaf_62_clk _1025_ VGND VGND VPWR VPWR memory\[1\]\[27\] sky130_fd_sc_hd__dfxtp_1
X_7397_ clknet_leaf_34_clk _0956_ VGND VGND VPWR VPWR memory\[25\]\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_98_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6417_ net877 _3262_ _3263_ _3267_ VGND VGND VPWR VPWR _0219_ sky130_fd_sc_hd__a31o_1
X_3629_ _1323_ _1325_ _1328_ _1207_ _1208_ VGND VGND VPWR VPWR _1329_ sky130_fd_sc_hd__a221o_1
XFILLER_0_31_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_113_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6348_ _2654_ _3231_ _3232_ net281 VGND VGND VPWR VPWR _0185_ sky130_fd_sc_hd__a22o_1
XFILLER_0_3_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6279_ net879 _3200_ _3196_ _3202_ VGND VGND VPWR VPWR _0146_ sky130_fd_sc_hd__a31o_1
XFILLER_0_98_447 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_109_402 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_109_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7428__124 VGND VGND VPWR VPWR _7428__124/HI net124 sky130_fd_sc_hd__conb_1
XPHY_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_120_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_118_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_7435__117 VGND VGND VPWR VPWR _7435__117/HI net117 sky130_fd_sc_hd__conb_1
XFILLER_0_27_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3980_ _1660_ _1661_ _1176_ VGND VGND VPWR VPWR _1662_ sky130_fd_sc_hd__mux2_1
XPHY_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_0_clk clk VGND VGND VPWR VPWR clknet_0_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_17_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5650_ _2840_ _2836_ VGND VGND VPWR VPWR _2841_ sky130_fd_sc_hd__and2_1
X_4601_ _2252_ _2253_ _1819_ VGND VGND VPWR VPWR _2254_ sky130_fd_sc_hd__mux2_1
XFILLER_0_115_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_115_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5581_ net986 _2798_ _2789_ _2799_ VGND VGND VPWR VPWR _0844_ sky130_fd_sc_hd__a31o_1
XFILLER_0_25_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7320_ clknet_leaf_96_clk _0879_ VGND VGND VPWR VPWR memory\[7\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_40_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4532_ memory\[4\]\[17\] memory\[5\]\[17\] memory\[6\]\[17\] memory\[7\]\[17\] _2014_
+ _2015_ VGND VGND VPWR VPWR _2189_ sky130_fd_sc_hd__mux4_1
XFILLER_0_111_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold326 memory\[2\]\[30\] VGND VGND VPWR VPWR net535 sky130_fd_sc_hd__dlygate4sd3_1
X_4463_ _1836_ _2123_ _1840_ VGND VGND VPWR VPWR _2124_ sky130_fd_sc_hd__o21a_1
Xhold315 memory\[12\]\[4\] VGND VGND VPWR VPWR net524 sky130_fd_sc_hd__dlygate4sd3_1
X_7251_ net154 _0026_ VGND VGND VPWR VPWR net108 sky130_fd_sc_hd__dfxtp_2
Xhold304 memory\[16\]\[7\] VGND VGND VPWR VPWR net513 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_25_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold337 memory\[15\]\[23\] VGND VGND VPWR VPWR net546 sky130_fd_sc_hd__dlygate4sd3_1
Xhold359 memory\[27\]\[23\] VGND VGND VPWR VPWR net568 sky130_fd_sc_hd__dlygate4sd3_1
Xhold348 memory\[29\]\[7\] VGND VGND VPWR VPWR net557 sky130_fd_sc_hd__dlygate4sd3_1
X_6202_ _2865_ _3154_ VGND VGND VPWR VPWR _3158_ sky130_fd_sc_hd__and2_1
X_7182_ clknet_leaf_46_clk _0773_ VGND VGND VPWR VPWR memory\[2\]\[31\] sky130_fd_sc_hd__dfxtp_1
X_4394_ _1798_ _2053_ _2055_ _2057_ _2038_ VGND VGND VPWR VPWR _2058_ sky130_fd_sc_hd__a221o_1
X_6133_ _2872_ _3110_ VGND VGND VPWR VPWR _3118_ sky130_fd_sc_hd__and2_1
XTAP_620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6064_ net762 _3075_ _3065_ _3077_ VGND VGND VPWR VPWR _1081_ sky130_fd_sc_hd__a31o_1
XTAP_653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5015_ _2559_ VGND VGND VPWR VPWR _2560_ sky130_fd_sc_hd__buf_2
XFILLER_0_84_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_23_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1819 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1808 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6966_ clknet_leaf_106_clk _0557_ VGND VGND VPWR VPWR memory\[6\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_5917_ _2884_ _2991_ VGND VGND VPWR VPWR _2993_ sky130_fd_sc_hd__and2_1
X_6897_ clknet_leaf_22_clk _0488_ VGND VGND VPWR VPWR memory\[15\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_36_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5848_ _2481_ _2946_ _2952_ VGND VGND VPWR VPWR _0958_ sky130_fd_sc_hd__a21o_1
XFILLER_0_106_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5779_ _2661_ _2915_ _2916_ net576 VGND VGND VPWR VPWR _0925_ sky130_fd_sc_hd__a22o_1
XFILLER_0_32_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_31_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7518_ clknet_leaf_77_clk _1077_ VGND VGND VPWR VPWR memory\[11\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_71_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7449_ clknet_leaf_79_clk _1008_ VGND VGND VPWR VPWR memory\[1\]\[10\] sky130_fd_sc_hd__dfxtp_1
Xhold882 memory\[28\]\[30\] VGND VGND VPWR VPWR net1091 sky130_fd_sc_hd__dlygate4sd3_1
Xhold860 memory\[22\]\[10\] VGND VGND VPWR VPWR net1069 sky130_fd_sc_hd__dlygate4sd3_1
Xhold871 memory\[30\]\[11\] VGND VGND VPWR VPWR net1080 sky130_fd_sc_hd__dlygate4sd3_1
Xhold893 memory\[22\]\[16\] VGND VGND VPWR VPWR net1102 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_86_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_94_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_82_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_120_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_38_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6820_ _2663_ _3443_ _3444_ net812 VGND VGND VPWR VPWR _0445_ sky130_fd_sc_hd__a22o_1
X_3963_ memory\[24\]\[23\] memory\[25\]\[23\] memory\[26\]\[23\] memory\[27\]\[23\]
+ _1551_ _1552_ VGND VGND VPWR VPWR _1646_ sky130_fd_sc_hd__mux4_1
XFILLER_0_85_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6751_ _2607_ _3429_ _3431_ net617 VGND VGND VPWR VPWR _0389_ sky130_fd_sc_hd__a22o_1
XFILLER_0_18_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3894_ _1486_ _1580_ _1488_ VGND VGND VPWR VPWR _1581_ sky130_fd_sc_hd__o21a_1
X_6682_ net41 _3388_ VGND VGND VPWR VPWR _3392_ sky130_fd_sc_hd__and2_1
XFILLER_0_57_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5702_ _2876_ _2859_ VGND VGND VPWR VPWR _2877_ sky130_fd_sc_hd__and2_1
XFILLER_0_116_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5633_ net820 _2824_ _2816_ _2828_ VGND VGND VPWR VPWR _0867_ sky130_fd_sc_hd__a31o_1
X_5564_ _2788_ VGND VGND VPWR VPWR _2789_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_14_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold101 memory\[31\]\[26\] VGND VGND VPWR VPWR net310 sky130_fd_sc_hd__dlygate4sd3_1
X_7303_ clknet_leaf_55_clk _0862_ VGND VGND VPWR VPWR memory\[8\]\[24\] sky130_fd_sc_hd__dfxtp_1
X_4515_ _1829_ _2172_ VGND VGND VPWR VPWR _2173_ sky130_fd_sc_hd__or2_1
XFILLER_0_13_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold134 memory\[14\]\[0\] VGND VGND VPWR VPWR net343 sky130_fd_sc_hd__dlygate4sd3_1
Xhold123 memory\[14\]\[8\] VGND VGND VPWR VPWR net332 sky130_fd_sc_hd__dlygate4sd3_1
Xhold112 memory\[28\]\[18\] VGND VGND VPWR VPWR net321 sky130_fd_sc_hd__dlygate4sd3_1
X_5495_ _2619_ _2776_ _2778_ net919 VGND VGND VPWR VPWR _0811_ sky130_fd_sc_hd__a22o_1
Xhold167 memory\[15\]\[21\] VGND VGND VPWR VPWR net376 sky130_fd_sc_hd__dlygate4sd3_1
Xhold145 memory\[9\]\[24\] VGND VGND VPWR VPWR net354 sky130_fd_sc_hd__dlygate4sd3_1
Xhold156 memory\[17\]\[12\] VGND VGND VPWR VPWR net365 sky130_fd_sc_hd__dlygate4sd3_1
X_7234_ clknet_leaf_78_clk _0825_ VGND VGND VPWR VPWR memory\[31\]\[19\] sky130_fd_sc_hd__dfxtp_1
X_4446_ _2097_ _2100_ _2103_ _2107_ _2066_ VGND VGND VPWR VPWR _2108_ sky130_fd_sc_hd__a221o_1
Xhold178 memory\[14\]\[28\] VGND VGND VPWR VPWR net387 sky130_fd_sc_hd__dlygate4sd3_1
X_7165_ clknet_leaf_68_clk _0756_ VGND VGND VPWR VPWR memory\[2\]\[14\] sky130_fd_sc_hd__dfxtp_1
Xhold189 memory\[1\]\[14\] VGND VGND VPWR VPWR net398 sky130_fd_sc_hd__dlygate4sd3_1
X_4377_ _2040_ _2041_ _1869_ VGND VGND VPWR VPWR _2042_ sky130_fd_sc_hd__mux2_1
X_6116_ _2855_ _3097_ VGND VGND VPWR VPWR _3108_ sky130_fd_sc_hd__and2_1
XFILLER_0_0_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7418__134 VGND VGND VPWR VPWR _7418__134/HI net134 sky130_fd_sc_hd__conb_1
XTAP_461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7096_ clknet_leaf_9_clk _0687_ VGND VGND VPWR VPWR memory\[29\]\[9\] sky130_fd_sc_hd__dfxtp_1
X_6047_ net949 _3062_ _3065_ _3068_ VGND VGND VPWR VPWR _1073_ sky130_fd_sc_hd__a31o_1
XFILLER_0_96_704 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6949_ clknet_leaf_54_clk _0540_ VGND VGND VPWR VPWR memory\[10\]\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_64_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_119_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7425__127 VGND VGND VPWR VPWR _7425__127/HI net127 sky130_fd_sc_hd__conb_1
XFILLER_0_17_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold690 memory\[23\]\[28\] VGND VGND VPWR VPWR net899 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_115_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_24_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_42_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4300_ _1796_ VGND VGND VPWR VPWR _1968_ sky130_fd_sc_hd__clkbuf_8
X_5280_ _2642_ _2708_ VGND VGND VPWR VPWR _2714_ sky130_fd_sc_hd__and2_1
XFILLER_0_10_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4231_ memory\[16\]\[3\] memory\[17\]\[3\] memory\[18\]\[3\] memory\[19\]\[3\] _1804_
+ _1805_ VGND VGND VPWR VPWR _1902_ sky130_fd_sc_hd__mux4_1
X_4162_ _1808_ VGND VGND VPWR VPWR _1836_ sky130_fd_sc_hd__buf_4
X_4093_ _1236_ _1764_ _1766_ _1768_ _1183_ VGND VGND VPWR VPWR _1769_ sky130_fd_sc_hd__a221o_1
XFILLER_0_65_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7921_ net184 _0054_ VGND VGND VPWR VPWR net72 sky130_fd_sc_hd__dfxtp_2
X_6840__48 clknet_1_0__leaf__3445_ VGND VGND VPWR VPWR net193 sky130_fd_sc_hd__inv_2
X_7852_ clknet_leaf_38_clk _0386_ VGND VGND VPWR VPWR memory\[9\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_77_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7783_ clknet_leaf_36_clk _0317_ VGND VGND VPWR VPWR memory\[30\]\[24\] sky130_fd_sc_hd__dfxtp_1
X_4995_ net1135 _2543_ _2540_ VGND VGND VPWR VPWR _2547_ sky130_fd_sc_hd__and3_1
X_6803_ _3439_ VGND VGND VPWR VPWR _3442_ sky130_fd_sc_hd__clkbuf_4
X_6734_ net34 _3414_ VGND VGND VPWR VPWR _3421_ sky130_fd_sc_hd__and2_1
X_3946_ _1588_ _1629_ VGND VGND VPWR VPWR _1630_ sky130_fd_sc_hd__or2_1
XFILLER_0_45_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6665_ _2667_ _3382_ _3383_ net441 VGND VGND VPWR VPWR _0351_ sky130_fd_sc_hd__a22o_1
X_3877_ _1559_ _1561_ _1564_ _1207_ _1412_ VGND VGND VPWR VPWR _1565_ sky130_fd_sc_hd__a221o_1
XFILLER_0_5_230 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5616_ net463 _2811_ _2816_ _2819_ VGND VGND VPWR VPWR _0859_ sky130_fd_sc_hd__a31o_1
X_6596_ _2613_ _3368_ _3370_ net947 VGND VGND VPWR VPWR _0295_ sky130_fd_sc_hd__a22o_1
X_5478_ _2482_ _2772_ _2773_ net252 VGND VGND VPWR VPWR _0799_ sky130_fd_sc_hd__a22o_1
XFILLER_0_41_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4429_ _1812_ _2090_ VGND VGND VPWR VPWR _2091_ sky130_fd_sc_hd__or2_1
X_7217_ clknet_leaf_5_clk _0808_ VGND VGND VPWR VPWR memory\[31\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_7148_ clknet_leaf_57_clk _0739_ VGND VGND VPWR VPWR memory\[3\]\[29\] sky130_fd_sc_hd__dfxtp_1
X_7079_ clknet_leaf_48_clk _0670_ VGND VGND VPWR VPWR memory\[4\]\[24\] sky130_fd_sc_hd__dfxtp_1
XTAP_280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_1479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_119_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_107_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_119_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_99_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_534 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_35_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4780_ memory\[16\]\[31\] memory\[17\]\[31\] memory\[18\]\[31\] memory\[19\]\[31\]
+ _1804_ _1805_ VGND VGND VPWR VPWR _2423_ sky130_fd_sc_hd__mux4_1
X_3800_ _1491_ VGND VGND VPWR VPWR _0005_ sky130_fd_sc_hd__clkbuf_1
X_3731_ _1187_ VGND VGND VPWR VPWR _1426_ sky130_fd_sc_hd__buf_4
XFILLER_0_28_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_113_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6450_ _2845_ _3282_ VGND VGND VPWR VPWR _3287_ sky130_fd_sc_hd__and2_1
X_7408__144 VGND VGND VPWR VPWR _7408__144/HI net144 sky130_fd_sc_hd__conb_1
X_3662_ net6 VGND VGND VPWR VPWR _1360_ sky130_fd_sc_hd__clkbuf_8
X_5401_ _2487_ _2748_ _2750_ net221 VGND VGND VPWR VPWR _0740_ sky130_fd_sc_hd__a22o_1
X_6381_ net348 _3233_ _3236_ _3246_ VGND VGND VPWR VPWR _0204_ sky130_fd_sc_hd__a31o_1
XFILLER_0_42_147 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3593_ _1294_ VGND VGND VPWR VPWR _0026_ sky130_fd_sc_hd__buf_1
X_5332_ _2460_ _2739_ _2741_ net557 VGND VGND VPWR VPWR _0685_ sky130_fd_sc_hd__a22o_1
XFILLER_0_2_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5263_ _2600_ VGND VGND VPWR VPWR _2704_ sky130_fd_sc_hd__clkbuf_4
X_5194_ _2676_ _2608_ VGND VGND VPWR VPWR _2677_ sky130_fd_sc_hd__and2_1
X_7002_ clknet_leaf_95_clk _0593_ VGND VGND VPWR VPWR memory\[26\]\[11\] sky130_fd_sc_hd__dfxtp_1
X_4214_ _1884_ _1885_ _1809_ VGND VGND VPWR VPWR _1886_ sky130_fd_sc_hd__mux2_1
XFILLER_0_76_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4145_ _1808_ VGND VGND VPWR VPWR _1819_ sky130_fd_sc_hd__clkbuf_8
X_4076_ memory\[4\]\[29\] memory\[5\]\[29\] memory\[6\]\[29\] memory\[7\]\[29\] _1170_
+ _1172_ VGND VGND VPWR VPWR _1753_ sky130_fd_sc_hd__mux4_1
X_7415__137 VGND VGND VPWR VPWR _7415__137/HI net137 sky130_fd_sc_hd__conb_1
X_7904_ clknet_leaf_90_clk _0438_ VGND VGND VPWR VPWR memory\[17\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_78_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7835_ clknet_leaf_79_clk _0369_ VGND VGND VPWR VPWR memory\[9\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_93_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4978_ net1160 _2530_ _2526_ VGND VGND VPWR VPWR _2537_ sky130_fd_sc_hd__and3_1
XFILLER_0_19_656 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_7766_ clknet_leaf_6_clk _0300_ VGND VGND VPWR VPWR memory\[30\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_3929_ memory\[28\]\[21\] memory\[29\]\[21\] memory\[30\]\[21\] memory\[31\]\[21\]
+ _1592_ _1593_ VGND VGND VPWR VPWR _1614_ sky130_fd_sc_hd__mux4_1
X_6717_ net988 _3406_ _3400_ _3411_ VGND VGND VPWR VPWR _0375_ sky130_fd_sc_hd__a31o_1
X_7697_ clknet_leaf_110_clk _0231_ VGND VGND VPWR VPWR memory\[5\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_46_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6648_ _2634_ _3380_ _3381_ net357 VGND VGND VPWR VPWR _0336_ sky130_fd_sc_hd__a22o_1
XFILLER_0_6_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_116_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6579_ _2897_ _3352_ VGND VGND VPWR VPWR _3361_ sky130_fd_sc_hd__and2_1
XFILLER_0_14_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_64_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5950_ _2840_ _3010_ VGND VGND VPWR VPWR _3013_ sky130_fd_sc_hd__and2_1
X_4901_ _2466_ _2497_ _2498_ net587 VGND VGND VPWR VPWR _0496_ sky130_fd_sc_hd__a22o_1
XFILLER_0_1_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_7620_ clknet_leaf_27_clk _0154_ VGND VGND VPWR VPWR memory\[27\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_87_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5881_ net1095 _2968_ _2963_ _2972_ VGND VGND VPWR VPWR _1003_ sky130_fd_sc_hd__a31o_1
X_4832_ net17 VGND VGND VPWR VPWR _2463_ sky130_fd_sc_hd__buf_4
XFILLER_0_47_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4763_ _2405_ _2406_ _1819_ VGND VGND VPWR VPWR _2407_ sky130_fd_sc_hd__mux2_1
X_7551_ clknet_leaf_108_clk _1110_ VGND VGND VPWR VPWR memory\[20\]\[16\] sky130_fd_sc_hd__dfxtp_1
X_4694_ memory\[16\]\[26\] memory\[17\]\[26\] memory\[18\]\[26\] memory\[19\]\[26\]
+ _1970_ _1971_ VGND VGND VPWR VPWR _2342_ sky130_fd_sc_hd__mux4_1
X_6502_ _2897_ _3308_ VGND VGND VPWR VPWR _3316_ sky130_fd_sc_hd__and2_1
X_3714_ memory\[12\]\[10\] memory\[13\]\[10\] memory\[14\]\[10\] memory\[15\]\[10\]
+ _1251_ _1252_ VGND VGND VPWR VPWR _1410_ sky130_fd_sc_hd__mux4_1
XFILLER_0_55_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7482_ clknet_leaf_107_clk _1041_ VGND VGND VPWR VPWR memory\[24\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_15_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6433_ _2903_ _3237_ VGND VGND VPWR VPWR _3276_ sky130_fd_sc_hd__and2_1
X_3645_ memory\[12\]\[7\] memory\[13\]\[7\] memory\[14\]\[7\] memory\[15\]\[7\] _1251_
+ _1252_ VGND VGND VPWR VPWR _1344_ sky130_fd_sc_hd__mux4_1
XFILLER_0_3_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6364_ _2690_ _2736_ _3093_ VGND VGND VPWR VPWR _3237_ sky130_fd_sc_hd__and3_4
XFILLER_0_3_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3576_ memory\[16\]\[4\] memory\[17\]\[4\] memory\[18\]\[4\] memory\[19\]\[4\] _1161_
+ _1162_ VGND VGND VPWR VPWR _1278_ sky130_fd_sc_hd__mux4_1
X_6295_ net480 _3200_ _3209_ _3211_ VGND VGND VPWR VPWR _0153_ sky130_fd_sc_hd__a31o_1
X_5315_ _2676_ _2694_ VGND VGND VPWR VPWR _2734_ sky130_fd_sc_hd__and2_1
X_5246_ _2694_ VGND VGND VPWR VPWR _2695_ sky130_fd_sc_hd__buf_2
XFILLER_0_53_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold27 memory\[29\]\[23\] VGND VGND VPWR VPWR net236 sky130_fd_sc_hd__dlygate4sd3_1
Xhold16 memory\[31\]\[27\] VGND VGND VPWR VPWR net225 sky130_fd_sc_hd__dlygate4sd3_1
Xhold38 memory\[2\]\[21\] VGND VGND VPWR VPWR net247 sky130_fd_sc_hd__dlygate4sd3_1
Xhold49 memory\[16\]\[26\] VGND VGND VPWR VPWR net258 sky130_fd_sc_hd__dlygate4sd3_1
X_5177_ net33 VGND VGND VPWR VPWR _2665_ sky130_fd_sc_hd__buf_4
X_4128_ _1801_ VGND VGND VPWR VPWR _1802_ sky130_fd_sc_hd__buf_4
X_4059_ memory\[0\]\[28\] memory\[1\]\[28\] memory\[2\]\[28\] memory\[3\]\[28\] _1237_
+ _1238_ VGND VGND VPWR VPWR _1737_ sky130_fd_sc_hd__mux4_1
X_7818_ clknet_leaf_52_clk _0352_ VGND VGND VPWR VPWR memory\[12\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_93_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_108_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7749_ clknet_leaf_25_clk _0283_ VGND VGND VPWR VPWR memory\[22\]\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_46_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_107_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_16_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1040 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1073 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1062 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1051 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1095 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1084 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_108_650 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_4_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold508 memory\[7\]\[3\] VGND VGND VPWR VPWR net717 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_122_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold519 memory\[8\]\[22\] VGND VGND VPWR VPWR net728 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6080_ net419 _3075_ _3078_ _3086_ VGND VGND VPWR VPWR _1088_ sky130_fd_sc_hd__a31o_1
XFILLER_0_0_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5100_ _2611_ _2609_ VGND VGND VPWR VPWR _2612_ sky130_fd_sc_hd__and2_1
XTAP_802 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_813 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_824 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_835 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5031_ _2460_ _2556_ _2568_ VGND VGND VPWR VPWR _0557_ sky130_fd_sc_hd__a21o_1
XTAP_846 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_857 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_868 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_879 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6982_ clknet_leaf_56_clk _0573_ VGND VGND VPWR VPWR memory\[6\]\[23\] sky130_fd_sc_hd__dfxtp_1
X_5933_ net633 _2994_ _2990_ _3001_ VGND VGND VPWR VPWR _1026_ sky130_fd_sc_hd__a31o_1
XFILLER_0_87_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5864_ _2441_ _2960_ VGND VGND VPWR VPWR _2961_ sky130_fd_sc_hd__or2_1
XFILLER_0_8_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_7603_ clknet_leaf_116_clk _0137_ VGND VGND VPWR VPWR memory\[27\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_4815_ _2454_ _2449_ _2453_ net675 VGND VGND VPWR VPWR _0454_ sky130_fd_sc_hd__a22o_1
X_7534_ clknet_leaf_41_clk _1093_ VGND VGND VPWR VPWR memory\[11\]\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_56_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5795_ net1146 _2597_ _2921_ VGND VGND VPWR VPWR _2923_ sky130_fd_sc_hd__and3_1
X_4746_ _1836_ _2390_ _1840_ VGND VGND VPWR VPWR _2391_ sky130_fd_sc_hd__o21a_1
X_4677_ _2116_ _2325_ _2118_ VGND VGND VPWR VPWR _2326_ sky130_fd_sc_hd__o21a_1
X_7465_ clknet_leaf_63_clk _1024_ VGND VGND VPWR VPWR memory\[1\]\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_43_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7396_ clknet_leaf_34_clk _0955_ VGND VGND VPWR VPWR memory\[25\]\[21\] sky130_fd_sc_hd__dfxtp_1
X_6416_ _2886_ _3264_ VGND VGND VPWR VPWR _3267_ sky130_fd_sc_hd__and2_1
X_3628_ _1326_ _1327_ _1205_ VGND VGND VPWR VPWR _1328_ sky130_fd_sc_hd__mux2_1
X_6347_ _3227_ VGND VGND VPWR VPWR _3232_ sky130_fd_sc_hd__clkbuf_4
X_3559_ _1169_ _1261_ VGND VGND VPWR VPWR _1262_ sky130_fd_sc_hd__or2_1
X_6278_ _2865_ _3197_ VGND VGND VPWR VPWR _3202_ sky130_fd_sc_hd__and2_1
X_5229_ _2475_ _2688_ _2689_ net407 VGND VGND VPWR VPWR _0634_ sky130_fd_sc_hd__a22o_1
XFILLER_0_98_459 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_85_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_562 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_34_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_90 net102 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_105_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_120_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_104_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_118_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_118_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4600_ memory\[16\]\[21\] memory\[17\]\[21\] memory\[18\]\[21\] memory\[19\]\[21\]
+ _2028_ _2029_ VGND VGND VPWR VPWR _2253_ sky130_fd_sc_hd__mux4_1
XFILLER_0_85_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5580_ _2621_ _2791_ VGND VGND VPWR VPWR _2799_ sky130_fd_sc_hd__and2_1
X_4531_ _2182_ _2184_ _2187_ _1978_ _2038_ VGND VGND VPWR VPWR _2188_ sky130_fd_sc_hd__a221o_1
Xhold305 memory\[30\]\[30\] VGND VGND VPWR VPWR net514 sky130_fd_sc_hd__dlygate4sd3_1
X_4462_ memory\[12\]\[13\] memory\[13\]\[13\] memory\[14\]\[13\] memory\[15\]\[13\]
+ _1973_ _1974_ VGND VGND VPWR VPWR _2123_ sky130_fd_sc_hd__mux4_1
Xhold316 memory\[17\]\[17\] VGND VGND VPWR VPWR net525 sky130_fd_sc_hd__dlygate4sd3_1
X_7250_ net153 _0025_ VGND VGND VPWR VPWR net107 sky130_fd_sc_hd__dfxtp_1
Xhold349 memory\[13\]\[14\] VGND VGND VPWR VPWR net558 sky130_fd_sc_hd__dlygate4sd3_1
Xhold327 memory\[8\]\[8\] VGND VGND VPWR VPWR net536 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_7_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6201_ net872 _3146_ _3153_ _3157_ VGND VGND VPWR VPWR _1138_ sky130_fd_sc_hd__a31o_1
Xhold338 memory\[19\]\[0\] VGND VGND VPWR VPWR net547 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_111_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7181_ clknet_leaf_46_clk _0772_ VGND VGND VPWR VPWR memory\[2\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_0_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4393_ _1820_ _2056_ _1824_ VGND VGND VPWR VPWR _2057_ sky130_fd_sc_hd__o21a_1
XTAP_610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6132_ _3005_ VGND VGND VPWR VPWR _3117_ sky130_fd_sc_hd__clkbuf_8
XTAP_643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6063_ _2878_ _3066_ VGND VGND VPWR VPWR _3077_ sky130_fd_sc_hd__and2_1
XTAP_654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5014_ _2510_ _2501_ _2558_ VGND VGND VPWR VPWR _2559_ sky130_fd_sc_hd__nand3_4
XTAP_687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1809 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6965_ clknet_leaf_107_clk _0556_ VGND VGND VPWR VPWR memory\[6\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_48_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5916_ net817 _2981_ _2990_ _2992_ VGND VGND VPWR VPWR _1018_ sky130_fd_sc_hd__a31o_1
XFILLER_0_88_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_119_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6896_ clknet_leaf_6_clk _0487_ VGND VGND VPWR VPWR memory\[15\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_5847_ net1145 _2943_ _2947_ VGND VGND VPWR VPWR _2952_ sky130_fd_sc_hd__and3_1
XFILLER_0_63_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_90 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5778_ _2659_ _2915_ _2916_ net961 VGND VGND VPWR VPWR _0924_ sky130_fd_sc_hd__a22o_1
X_4729_ _1959_ _2374_ VGND VGND VPWR VPWR _2375_ sky130_fd_sc_hd__or2_1
XFILLER_0_32_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7517_ clknet_leaf_79_clk _1076_ VGND VGND VPWR VPWR memory\[11\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_121_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_102_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_110_clk clknet_4_1_0_clk VGND VGND VPWR VPWR clknet_leaf_110_clk sky130_fd_sc_hd__clkbuf_16
X_7448_ clknet_leaf_102_clk _1007_ VGND VGND VPWR VPWR memory\[1\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_101_100 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_4_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold872 memory\[27\]\[30\] VGND VGND VPWR VPWR net1081 sky130_fd_sc_hd__dlygate4sd3_1
Xhold861 memory\[8\]\[12\] VGND VGND VPWR VPWR net1070 sky130_fd_sc_hd__dlygate4sd3_1
X_7379_ clknet_leaf_0_clk _0938_ VGND VGND VPWR VPWR memory\[25\]\[4\] sky130_fd_sc_hd__dfxtp_1
Xhold850 memory\[5\]\[16\] VGND VGND VPWR VPWR net1059 sky130_fd_sc_hd__dlygate4sd3_1
Xhold883 memory\[24\]\[21\] VGND VGND VPWR VPWR net1092 sky130_fd_sc_hd__dlygate4sd3_1
X_6846__54 clknet_1_1__leaf__3445_ VGND VGND VPWR VPWR net199 sky130_fd_sc_hd__inv_2
Xhold894 memory\[26\]\[16\] VGND VGND VPWR VPWR net1103 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_104_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_54_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_94_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_66_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_101_clk clknet_4_6_0_clk VGND VGND VPWR VPWR clknet_leaf_101_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_38_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_89_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_407 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6750_ _3430_ VGND VGND VPWR VPWR _3431_ sky130_fd_sc_hd__clkbuf_4
X_3962_ _1643_ _1644_ _1472_ VGND VGND VPWR VPWR _1645_ sky130_fd_sc_hd__mux2_1
XFILLER_0_58_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5701_ net25 VGND VGND VPWR VPWR _2876_ sky130_fd_sc_hd__clkbuf_4
X_3893_ memory\[12\]\[19\] memory\[13\]\[19\] memory\[14\]\[19\] memory\[15\]\[19\]
+ _1430_ _1431_ VGND VGND VPWR VPWR _1580_ sky130_fd_sc_hd__mux4_1
XFILLER_0_72_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6681_ net443 _3359_ _3386_ _3391_ VGND VGND VPWR VPWR _0359_ sky130_fd_sc_hd__a31o_1
X_5632_ _2673_ _2817_ VGND VGND VPWR VPWR _2828_ sky130_fd_sc_hd__and2_1
XFILLER_0_115_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5563_ _2691_ _2511_ VGND VGND VPWR VPWR _2788_ sky130_fd_sc_hd__nand2_2
XFILLER_0_5_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_7302_ clknet_leaf_57_clk _0861_ VGND VGND VPWR VPWR memory\[8\]\[23\] sky130_fd_sc_hd__dfxtp_1
X_4514_ memory\[8\]\[16\] memory\[9\]\[16\] memory\[10\]\[16\] memory\[11\]\[16\]
+ _1948_ _1949_ VGND VGND VPWR VPWR _2172_ sky130_fd_sc_hd__mux4_1
XFILLER_0_13_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold102 memory\[13\]\[28\] VGND VGND VPWR VPWR net311 sky130_fd_sc_hd__dlygate4sd3_1
Xhold124 memory\[17\]\[30\] VGND VGND VPWR VPWR net333 sky130_fd_sc_hd__dlygate4sd3_1
Xhold135 memory\[2\]\[14\] VGND VGND VPWR VPWR net344 sky130_fd_sc_hd__dlygate4sd3_1
Xhold113 memory\[24\]\[4\] VGND VGND VPWR VPWR net322 sky130_fd_sc_hd__dlygate4sd3_1
X_5494_ _2617_ _2776_ _2778_ net772 VGND VGND VPWR VPWR _0810_ sky130_fd_sc_hd__a22o_1
Xhold157 memory\[31\]\[25\] VGND VGND VPWR VPWR net366 sky130_fd_sc_hd__dlygate4sd3_1
Xhold146 memory\[14\]\[19\] VGND VGND VPWR VPWR net355 sky130_fd_sc_hd__dlygate4sd3_1
X_4445_ _2104_ _2105_ _2106_ VGND VGND VPWR VPWR _2107_ sky130_fd_sc_hd__o21a_1
XFILLER_0_13_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold168 memory\[27\]\[18\] VGND VGND VPWR VPWR net377 sky130_fd_sc_hd__dlygate4sd3_1
X_7233_ clknet_leaf_78_clk _0824_ VGND VGND VPWR VPWR memory\[31\]\[18\] sky130_fd_sc_hd__dfxtp_1
Xhold179 memory\[19\]\[29\] VGND VGND VPWR VPWR net388 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_1_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4376_ memory\[0\]\[9\] memory\[1\]\[9\] memory\[2\]\[9\] memory\[3\]\[9\] _2017_
+ _2018_ VGND VGND VPWR VPWR _2041_ sky130_fd_sc_hd__mux4_1
X_7164_ clknet_leaf_82_clk _0755_ VGND VGND VPWR VPWR memory\[2\]\[13\] sky130_fd_sc_hd__dfxtp_1
X_6115_ net955 _3104_ _3095_ _3107_ VGND VGND VPWR VPWR _1102_ sky130_fd_sc_hd__a31o_1
XTAP_451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7095_ clknet_leaf_8_clk _0686_ VGND VGND VPWR VPWR memory\[29\]\[8\] sky130_fd_sc_hd__dfxtp_1
XTAP_462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6046_ _2861_ _3066_ VGND VGND VPWR VPWR _3068_ sky130_fd_sc_hd__and2_1
XTAP_495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_716 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6948_ clknet_leaf_55_clk _0539_ VGND VGND VPWR VPWR memory\[10\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_76_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6879_ clknet_leaf_77_clk _0470_ VGND VGND VPWR VPWR memory\[28\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_91_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_63_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold680 memory\[31\]\[15\] VGND VGND VPWR VPWR net889 sky130_fd_sc_hd__dlygate4sd3_1
Xhold691 memory\[31\]\[30\] VGND VGND VPWR VPWR net900 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_87_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_115_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_39_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4230_ memory\[20\]\[3\] memory\[21\]\[3\] memory\[22\]\[3\] memory\[23\]\[3\] _1800_
+ _1802_ VGND VGND VPWR VPWR _1901_ sky130_fd_sc_hd__mux4_1
X_4161_ _1829_ _1834_ VGND VGND VPWR VPWR _1835_ sky130_fd_sc_hd__or2_1
X_4092_ _1250_ _1767_ _1254_ VGND VGND VPWR VPWR _1768_ sky130_fd_sc_hd__o21a_1
X_7920_ net183 _0043_ VGND VGND VPWR VPWR net61 sky130_fd_sc_hd__dfxtp_2
X_7851_ clknet_leaf_38_clk _0385_ VGND VGND VPWR VPWR memory\[9\]\[28\] sky130_fd_sc_hd__dfxtp_1
X_6802_ _3437_ VGND VGND VPWR VPWR _3441_ sky130_fd_sc_hd__clkbuf_4
X_7782_ clknet_leaf_35_clk _0316_ VGND VGND VPWR VPWR memory\[30\]\[23\] sky130_fd_sc_hd__dfxtp_1
X_4994_ _2481_ _2539_ _2546_ VGND VGND VPWR VPWR _0542_ sky130_fd_sc_hd__a21o_1
XFILLER_0_81_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6733_ net1099 _2509_ _3413_ _3420_ VGND VGND VPWR VPWR _0382_ sky130_fd_sc_hd__a31o_1
X_3945_ memory\[24\]\[22\] memory\[25\]\[22\] memory\[26\]\[22\] memory\[27\]\[22\]
+ _1551_ _1552_ VGND VGND VPWR VPWR _1629_ sky130_fd_sc_hd__mux4_1
XFILLER_0_73_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6664_ _2665_ _3382_ _3383_ net404 VGND VGND VPWR VPWR _0350_ sky130_fd_sc_hd__a22o_1
X_5615_ _2657_ _2817_ VGND VGND VPWR VPWR _2819_ sky130_fd_sc_hd__and2_1
XFILLER_0_73_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3876_ _1562_ _1563_ _1166_ VGND VGND VPWR VPWR _1564_ sky130_fd_sc_hd__mux2_1
XFILLER_0_45_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_116_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_103_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_5_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6595_ _2611_ _3368_ _3370_ net429 VGND VGND VPWR VPWR _0294_ sky130_fd_sc_hd__a22o_1
XFILLER_0_14_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5477_ _2481_ _2772_ _2773_ net449 VGND VGND VPWR VPWR _0798_ sky130_fd_sc_hd__a22o_1
XFILLER_0_14_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_111_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4428_ memory\[24\]\[12\] memory\[25\]\[12\] memory\[26\]\[12\] memory\[27\]\[12\]
+ _2032_ _2033_ VGND VGND VPWR VPWR _2090_ sky130_fd_sc_hd__mux4_1
X_7216_ clknet_leaf_5_clk _0807_ VGND VGND VPWR VPWR memory\[31\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_7147_ clknet_leaf_64_clk _0738_ VGND VGND VPWR VPWR memory\[3\]\[28\] sky130_fd_sc_hd__dfxtp_1
X_4359_ _1862_ _2020_ _2022_ _2024_ _1851_ VGND VGND VPWR VPWR _2025_ sky130_fd_sc_hd__a221o_1
X_7078_ clknet_leaf_56_clk _0669_ VGND VGND VPWR VPWR memory\[4\]\[23\] sky130_fd_sc_hd__dfxtp_1
XTAP_281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6029_ _2845_ _3053_ VGND VGND VPWR VPWR _3058_ sky130_fd_sc_hd__and2_1
X_7431__121 VGND VGND VPWR VPWR _7431__121/HI net121 sky130_fd_sc_hd__conb_1
XTAP_1414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_592 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_51_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_204 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_59_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3730_ _1423_ _1424_ _1243_ VGND VGND VPWR VPWR _1425_ sky130_fd_sc_hd__mux2_1
XFILLER_0_55_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3661_ _1155_ _1352_ _1356_ _1358_ _1184_ VGND VGND VPWR VPWR _1359_ sky130_fd_sc_hd__a221o_1
X_5400_ _2486_ _2754_ _2755_ net808 VGND VGND VPWR VPWR _0739_ sky130_fd_sc_hd__a22o_1
X_6380_ _2851_ _3238_ VGND VGND VPWR VPWR _3246_ sky130_fd_sc_hd__and2_1
XFILLER_0_42_159 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3592_ _1285_ _1293_ VGND VGND VPWR VPWR _1294_ sky130_fd_sc_hd__and2_1
XFILLER_0_113_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5331_ _2459_ _2739_ _2741_ net538 VGND VGND VPWR VPWR _0684_ sky130_fd_sc_hd__a22o_1
XFILLER_0_51_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5262_ net1017 _2675_ _2693_ _2703_ VGND VGND VPWR VPWR _0653_ sky130_fd_sc_hd__a31o_1
X_7001_ clknet_leaf_95_clk _0592_ VGND VGND VPWR VPWR memory\[26\]\[10\] sky130_fd_sc_hd__dfxtp_1
X_5193_ net39 VGND VGND VPWR VPWR _2676_ sky130_fd_sc_hd__buf_4
X_4213_ memory\[16\]\[2\] memory\[17\]\[2\] memory\[18\]\[2\] memory\[19\]\[2\] _1804_
+ _1805_ VGND VGND VPWR VPWR _1885_ sky130_fd_sc_hd__mux4_1
X_4144_ _1812_ _1817_ VGND VGND VPWR VPWR _1818_ sky130_fd_sc_hd__or2_1
X_4075_ _1584_ _1747_ _1749_ _1751_ _1597_ VGND VGND VPWR VPWR _1752_ sky130_fd_sc_hd__a221o_1
XFILLER_0_78_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7903_ clknet_leaf_90_clk _0437_ VGND VGND VPWR VPWR memory\[17\]\[16\] sky130_fd_sc_hd__dfxtp_1
X_7834_ clknet_leaf_74_clk _0368_ VGND VGND VPWR VPWR memory\[9\]\[11\] sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_90_clk clknet_4_5_0_clk VGND VGND VPWR VPWR clknet_leaf_90_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_65_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7765_ clknet_leaf_7_clk _0299_ VGND VGND VPWR VPWR memory\[30\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_19_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4977_ _2472_ _2525_ _2536_ VGND VGND VPWR VPWR _0535_ sky130_fd_sc_hd__a21o_1
XFILLER_0_46_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6716_ net25 _3401_ VGND VGND VPWR VPWR _3411_ sky130_fd_sc_hd__and2_1
X_3928_ _1588_ _1612_ VGND VGND VPWR VPWR _1613_ sky130_fd_sc_hd__or2_1
XFILLER_0_73_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7696_ clknet_leaf_108_clk _0230_ VGND VGND VPWR VPWR memory\[5\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_19_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6647_ _2631_ _3380_ _3381_ net1076 VGND VGND VPWR VPWR _0335_ sky130_fd_sc_hd__a22o_1
XFILLER_0_18_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3859_ _1156_ VGND VGND VPWR VPWR _1547_ sky130_fd_sc_hd__buf_8
X_6578_ net1051 _3359_ _3351_ _3360_ VGND VGND VPWR VPWR _0287_ sky130_fd_sc_hd__a31o_1
XFILLER_0_33_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5552__27 clknet_1_1__leaf__2786_ VGND VGND VPWR VPWR net172 sky130_fd_sc_hd__inv_2
XFILLER_0_41_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_100_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_96_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_81_clk clknet_4_7_0_clk VGND VGND VPWR VPWR clknet_leaf_81_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_84_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_112_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_64_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4900_ _2463_ _2497_ _2498_ net262 VGND VGND VPWR VPWR _0495_ sky130_fd_sc_hd__a22o_1
X_5880_ _2847_ _2965_ VGND VGND VPWR VPWR _2972_ sky130_fd_sc_hd__and2_1
XFILLER_0_87_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_leaf_72_clk clknet_4_12_0_clk VGND VGND VPWR VPWR clknet_leaf_72_clk sky130_fd_sc_hd__clkbuf_16
X_4831_ _2462_ _2449_ _2453_ net624 VGND VGND VPWR VPWR _0462_ sky130_fd_sc_hd__a22o_1
XFILLER_0_28_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4762_ memory\[16\]\[30\] memory\[17\]\[30\] memory\[18\]\[30\] memory\[19\]\[30\]
+ _1800_ _1802_ VGND VGND VPWR VPWR _2406_ sky130_fd_sc_hd__mux4_1
X_7550_ clknet_leaf_94_clk _1109_ VGND VGND VPWR VPWR memory\[20\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_16_616 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4693_ memory\[20\]\[26\] memory\[21\]\[26\] memory\[22\]\[26\] memory\[23\]\[26\]
+ _1831_ _1833_ VGND VGND VPWR VPWR _2341_ sky130_fd_sc_hd__mux4_1
X_6501_ net1067 _3304_ _3307_ _3315_ VGND VGND VPWR VPWR _0255_ sky130_fd_sc_hd__a31o_1
XFILLER_0_71_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7481_ clknet_leaf_95_clk _1040_ VGND VGND VPWR VPWR memory\[24\]\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_28_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3713_ _1245_ _1408_ VGND VGND VPWR VPWR _1409_ sky130_fd_sc_hd__or2_1
XFILLER_0_113_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6432_ _3145_ VGND VGND VPWR VPWR _3275_ sky130_fd_sc_hd__buf_4
X_3644_ _1245_ _1342_ VGND VGND VPWR VPWR _1343_ sky130_fd_sc_hd__or2_1
X_7421__131 VGND VGND VPWR VPWR _7421__131/HI net131 sky130_fd_sc_hd__conb_1
X_6363_ _3235_ VGND VGND VPWR VPWR _3236_ sky130_fd_sc_hd__clkbuf_4
X_3575_ memory\[20\]\[4\] memory\[21\]\[4\] memory\[22\]\[4\] memory\[23\]\[4\] _1157_
+ _1159_ VGND VGND VPWR VPWR _1277_ sky130_fd_sc_hd__mux4_1
X_6294_ _2881_ _3210_ VGND VGND VPWR VPWR _3211_ sky130_fd_sc_hd__and2_1
X_5314_ net876 _2731_ _2720_ _2733_ VGND VGND VPWR VPWR _0675_ sky130_fd_sc_hd__a31o_1
X_5245_ _2440_ _2441_ _2690_ _2558_ VGND VGND VPWR VPWR _2694_ sky130_fd_sc_hd__and4_4
Xhold28 memory\[12\]\[17\] VGND VGND VPWR VPWR net237 sky130_fd_sc_hd__dlygate4sd3_1
Xhold17 memory\[28\]\[19\] VGND VGND VPWR VPWR net226 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_46_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5176_ net490 _2652_ _2653_ _2664_ VGND VGND VPWR VPWR _0606_ sky130_fd_sc_hd__a31o_1
Xhold39 memory\[2\]\[31\] VGND VGND VPWR VPWR net248 sky130_fd_sc_hd__dlygate4sd3_1
X_4127_ net2 VGND VGND VPWR VPWR _1801_ sky130_fd_sc_hd__buf_4
X_4058_ memory\[4\]\[28\] memory\[5\]\[28\] memory\[6\]\[28\] memory\[7\]\[28\] _1170_
+ _1172_ VGND VGND VPWR VPWR _1736_ sky130_fd_sc_hd__mux4_1
Xclkbuf_leaf_63_clk clknet_4_15_0_clk VGND VGND VPWR VPWR clknet_leaf_63_clk sky130_fd_sc_hd__clkbuf_16
X_7817_ clknet_leaf_53_clk _0351_ VGND VGND VPWR VPWR memory\[12\]\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_109_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_19_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7748_ clknet_leaf_23_clk _0282_ VGND VGND VPWR VPWR memory\[22\]\[21\] sky130_fd_sc_hd__dfxtp_1
X_7679_ clknet_leaf_108_clk _0213_ VGND VGND VPWR VPWR memory\[21\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_117_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_34_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_54_clk clknet_4_14_0_clk VGND VGND VPWR VPWR clknet_leaf_54_clk sky130_fd_sc_hd__clkbuf_16
XTAP_1030 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1074 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1063 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1052 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1041 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1096 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1085 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_108_662 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_80_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold509 memory\[20\]\[5\] VGND VGND VPWR VPWR net718 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_803 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_814 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_825 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5030_ net1129 _2557_ _2560_ VGND VGND VPWR VPWR _2568_ sky130_fd_sc_hd__and3_1
XTAP_836 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_847 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_858 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_869 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6981_ clknet_leaf_62_clk _0572_ VGND VGND VPWR VPWR memory\[6\]\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_73_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5932_ _2899_ _2991_ VGND VGND VPWR VPWR _3001_ sky130_fd_sc_hd__and2_1
XFILLER_0_88_674 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_45_clk clknet_4_12_0_clk VGND VGND VPWR VPWR clknet_leaf_45_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_73_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5863_ _2489_ _2736_ VGND VGND VPWR VPWR _2960_ sky130_fd_sc_hd__nand2_1
XFILLER_0_118_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4814_ net27 VGND VGND VPWR VPWR _2454_ sky130_fd_sc_hd__clkbuf_8
X_5794_ _2439_ _2919_ _2922_ VGND VGND VPWR VPWR _0934_ sky130_fd_sc_hd__a21o_1
X_7602_ clknet_leaf_4_clk _0136_ VGND VGND VPWR VPWR memory\[27\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_4745_ memory\[28\]\[29\] memory\[29\]\[29\] memory\[30\]\[29\] memory\[31\]\[29\]
+ _1960_ _1961_ VGND VGND VPWR VPWR _2390_ sky130_fd_sc_hd__mux4_1
X_7533_ clknet_leaf_45_clk _1092_ VGND VGND VPWR VPWR memory\[11\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_8_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_7_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4676_ memory\[28\]\[25\] memory\[29\]\[25\] memory\[30\]\[25\] memory\[31\]\[25\]
+ _2092_ _2093_ VGND VGND VPWR VPWR _2325_ sky130_fd_sc_hd__mux4_1
XFILLER_0_113_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7464_ clknet_leaf_71_clk _1023_ VGND VGND VPWR VPWR memory\[1\]\[25\] sky130_fd_sc_hd__dfxtp_1
X_7395_ clknet_leaf_31_clk _0954_ VGND VGND VPWR VPWR memory\[25\]\[20\] sky130_fd_sc_hd__dfxtp_1
X_6415_ net868 _3262_ _3263_ _3266_ VGND VGND VPWR VPWR _0218_ sky130_fd_sc_hd__a31o_1
XFILLER_0_3_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3627_ memory\[0\]\[6\] memory\[1\]\[6\] memory\[2\]\[6\] memory\[3\]\[6\] _1271_
+ _1272_ VGND VGND VPWR VPWR _1327_ sky130_fd_sc_hd__mux4_1
X_6346_ _3225_ VGND VGND VPWR VPWR _3231_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_12_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3558_ memory\[24\]\[3\] memory\[25\]\[3\] memory\[26\]\[3\] memory\[27\]\[3\] _1171_
+ _1173_ VGND VGND VPWR VPWR _1261_ sky130_fd_sc_hd__mux4_1
X_3489_ _1189_ VGND VGND VPWR VPWR _1195_ sky130_fd_sc_hd__clkbuf_8
X_6277_ net958 _3200_ _3196_ _3201_ VGND VGND VPWR VPWR _0145_ sky130_fd_sc_hd__a31o_1
X_5228_ _2684_ VGND VGND VPWR VPWR _2689_ sky130_fd_sc_hd__clkbuf_4
X_5159_ _2600_ VGND VGND VPWR VPWR _2652_ sky130_fd_sc_hd__clkbuf_4
Xclkbuf_leaf_36_clk clknet_4_11_0_clk VGND VGND VPWR VPWR clknet_leaf_36_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_94_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_688 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_93_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_109_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_80 net78 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_91 net106 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_120_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_27_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_89_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_27_clk clknet_4_10_0_clk VGND VGND VPWR VPWR clknet_leaf_27_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_85_644 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_57_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7411__141 VGND VGND VPWR VPWR _7411__141/HI net141 sky130_fd_sc_hd__conb_1
XFILLER_0_38_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4530_ _2185_ _2186_ _1848_ VGND VGND VPWR VPWR _2187_ sky130_fd_sc_hd__mux2_1
XFILLER_0_25_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold306 memory\[11\]\[9\] VGND VGND VPWR VPWR net515 sky130_fd_sc_hd__dlygate4sd3_1
X_4461_ _1829_ _2121_ VGND VGND VPWR VPWR _2122_ sky130_fd_sc_hd__or2_1
Xhold317 memory\[21\]\[5\] VGND VGND VPWR VPWR net526 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7180_ clknet_leaf_57_clk _0771_ VGND VGND VPWR VPWR memory\[2\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_7_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold328 memory\[21\]\[8\] VGND VGND VPWR VPWR net537 sky130_fd_sc_hd__dlygate4sd3_1
X_6200_ _2863_ _3154_ VGND VGND VPWR VPWR _3157_ sky130_fd_sc_hd__and2_1
XFILLER_0_40_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold339 memory\[9\]\[12\] VGND VGND VPWR VPWR net548 sky130_fd_sc_hd__dlygate4sd3_1
X_6131_ net466 _3104_ _3109_ _3116_ VGND VGND VPWR VPWR _1109_ sky130_fd_sc_hd__a31o_1
XTAP_600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4392_ memory\[28\]\[10\] memory\[29\]\[10\] memory\[30\]\[10\] memory\[31\]\[10\]
+ _1821_ _1822_ VGND VGND VPWR VPWR _2056_ sky130_fd_sc_hd__mux4_1
XFILLER_0_110_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6062_ net454 _3075_ _3065_ _3076_ VGND VGND VPWR VPWR _1080_ sky130_fd_sc_hd__a31o_1
XTAP_644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5013_ _2443_ _2444_ _2445_ VGND VGND VPWR VPWR _2558_ sky130_fd_sc_hd__nor3b_4
XTAP_688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_108_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_18_clk clknet_4_8_0_clk VGND VGND VPWR VPWR clknet_leaf_18_clk sky130_fd_sc_hd__clkbuf_16
X_6964_ clknet_leaf_105_clk _0555_ VGND VGND VPWR VPWR memory\[6\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_5915_ _2881_ _2991_ VGND VGND VPWR VPWR _2992_ sky130_fd_sc_hd__and2_1
X_6895_ clknet_leaf_23_clk _0486_ VGND VGND VPWR VPWR memory\[15\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_75_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5846_ _2480_ _2946_ _2951_ VGND VGND VPWR VPWR _0957_ sky130_fd_sc_hd__a21o_1
XFILLER_0_76_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_48_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_118_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5777_ _2657_ _2915_ _2916_ net920 VGND VGND VPWR VPWR _0923_ sky130_fd_sc_hd__a22o_1
X_4728_ memory\[24\]\[28\] memory\[25\]\[28\] memory\[26\]\[28\] memory\[27\]\[28\]
+ _1877_ _1878_ VGND VGND VPWR VPWR _2374_ sky130_fd_sc_hd__mux4_1
X_7516_ clknet_leaf_74_clk _1075_ VGND VGND VPWR VPWR memory\[11\]\[13\] sky130_fd_sc_hd__dfxtp_1
X_4659_ _2116_ _2308_ _2118_ VGND VGND VPWR VPWR _2309_ sky130_fd_sc_hd__o21a_1
X_7447_ clknet_leaf_100_clk _1006_ VGND VGND VPWR VPWR memory\[1\]\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_114_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold862 memory\[17\]\[20\] VGND VGND VPWR VPWR net1071 sky130_fd_sc_hd__dlygate4sd3_1
Xhold851 memory\[22\]\[1\] VGND VGND VPWR VPWR net1060 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_3_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7378_ clknet_leaf_4_clk _0937_ VGND VGND VPWR VPWR memory\[25\]\[3\] sky130_fd_sc_hd__dfxtp_1
Xhold840 memory\[7\]\[8\] VGND VGND VPWR VPWR net1049 sky130_fd_sc_hd__dlygate4sd3_1
Xhold873 memory\[11\]\[10\] VGND VGND VPWR VPWR net1082 sky130_fd_sc_hd__dlygate4sd3_1
Xhold884 memory\[22\]\[22\] VGND VGND VPWR VPWR net1093 sky130_fd_sc_hd__dlygate4sd3_1
Xhold895 memory\[22\]\[21\] VGND VGND VPWR VPWR net1104 sky130_fd_sc_hd__dlygate4sd3_1
X_6329_ _2619_ _3226_ _3228_ net785 VGND VGND VPWR VPWR _0170_ sky130_fd_sc_hd__a22o_1
XFILLER_0_98_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_600 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_67_644 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_39_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_109_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_146 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_120_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_105_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_419 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3961_ memory\[16\]\[23\] memory\[17\]\[23\] memory\[18\]\[23\] memory\[19\]\[23\]
+ _1547_ _1548_ VGND VGND VPWR VPWR _1644_ sky130_fd_sc_hd__mux4_1
XFILLER_0_57_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5700_ net723 _2867_ _2857_ _2875_ VGND VGND VPWR VPWR _0887_ sky130_fd_sc_hd__a31o_1
X_3892_ _1483_ _1578_ VGND VGND VPWR VPWR _1579_ sky130_fd_sc_hd__or2_1
XFILLER_0_58_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6680_ net38 _3388_ VGND VGND VPWR VPWR _3391_ sky130_fd_sc_hd__and2_1
X_5631_ net1041 _2824_ _2816_ _2827_ VGND VGND VPWR VPWR _0866_ sky130_fd_sc_hd__a31o_1
X_7301_ clknet_leaf_54_clk _0860_ VGND VGND VPWR VPWR memory\[8\]\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_14_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4513_ _2086_ _2166_ _2168_ _2170_ _2038_ VGND VGND VPWR VPWR _2171_ sky130_fd_sc_hd__a221o_1
Xhold114 memory\[13\]\[24\] VGND VGND VPWR VPWR net323 sky130_fd_sc_hd__dlygate4sd3_1
Xhold103 memory\[15\]\[30\] VGND VGND VPWR VPWR net312 sky130_fd_sc_hd__dlygate4sd3_1
Xhold125 memory\[30\]\[16\] VGND VGND VPWR VPWR net334 sky130_fd_sc_hd__dlygate4sd3_1
X_7232_ clknet_leaf_100_clk _0823_ VGND VGND VPWR VPWR memory\[31\]\[17\] sky130_fd_sc_hd__dfxtp_1
X_5493_ _2615_ _2776_ _2778_ net328 VGND VGND VPWR VPWR _0809_ sky130_fd_sc_hd__a22o_1
Xhold147 memory\[30\]\[26\] VGND VGND VPWR VPWR net356 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_111_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_110_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4444_ _1796_ VGND VGND VPWR VPWR _2106_ sky130_fd_sc_hd__clkbuf_4
Xhold158 memory\[1\]\[18\] VGND VGND VPWR VPWR net367 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold136 memory\[29\]\[11\] VGND VGND VPWR VPWR net345 sky130_fd_sc_hd__dlygate4sd3_1
Xclkbuf_leaf_7_clk clknet_4_2_0_clk VGND VGND VPWR VPWR clknet_leaf_7_clk sky130_fd_sc_hd__clkbuf_16
Xhold169 memory\[29\]\[27\] VGND VGND VPWR VPWR net378 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_1_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4375_ memory\[4\]\[9\] memory\[5\]\[9\] memory\[6\]\[9\] memory\[7\]\[9\] _2014_
+ _2015_ VGND VGND VPWR VPWR _2040_ sky130_fd_sc_hd__mux4_1
X_7163_ clknet_leaf_81_clk _0754_ VGND VGND VPWR VPWR memory\[2\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_111_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6114_ _2853_ _3097_ VGND VGND VPWR VPWR _3107_ sky130_fd_sc_hd__and2_1
X_7094_ clknet_leaf_6_clk _0685_ VGND VGND VPWR VPWR memory\[29\]\[7\] sky130_fd_sc_hd__dfxtp_1
XTAP_452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6045_ net1082 _3062_ _3065_ _3067_ VGND VGND VPWR VPWR _1072_ sky130_fd_sc_hd__a31o_1
XTAP_496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_728 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6947_ clknet_leaf_53_clk _0538_ VGND VGND VPWR VPWR memory\[10\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_49_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_119_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6878_ clknet_leaf_87_clk _0469_ VGND VGND VPWR VPWR memory\[28\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_119_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5829_ _2471_ _2933_ _2941_ VGND VGND VPWR VPWR _0950_ sky130_fd_sc_hd__a21o_1
XFILLER_0_29_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold670 memory\[27\]\[13\] VGND VGND VPWR VPWR net879 sky130_fd_sc_hd__dlygate4sd3_1
Xhold681 memory\[1\]\[15\] VGND VGND VPWR VPWR net890 sky130_fd_sc_hd__dlygate4sd3_1
Xhold692 memory\[23\]\[4\] VGND VGND VPWR VPWR net901 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_99_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5558__33 clknet_1_0__leaf__2786_ VGND VGND VPWR VPWR net178 sky130_fd_sc_hd__inv_2
XFILLER_0_27_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_154 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_82_488 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_40_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_438 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_105_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_11_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_599 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_120_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5532__9 clknet_1_1__leaf__2784_ VGND VGND VPWR VPWR net154 sky130_fd_sc_hd__inv_2
XFILLER_0_4_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4160_ memory\[8\]\[0\] memory\[9\]\[0\] memory\[10\]\[0\] memory\[11\]\[0\] _1831_
+ _1833_ VGND VGND VPWR VPWR _1834_ sky130_fd_sc_hd__mux4_1
X_4091_ memory\[28\]\[30\] memory\[29\]\[30\] memory\[30\]\[30\] memory\[31\]\[30\]
+ _1171_ _1173_ VGND VGND VPWR VPWR _1767_ sky130_fd_sc_hd__mux4_1
X_7850_ clknet_leaf_51_clk _0384_ VGND VGND VPWR VPWR memory\[9\]\[27\] sky130_fd_sc_hd__dfxtp_1
X_6801_ _2627_ _3438_ _3440_ net289 VGND VGND VPWR VPWR _0430_ sky130_fd_sc_hd__a22o_1
X_7781_ clknet_leaf_36_clk _0315_ VGND VGND VPWR VPWR memory\[30\]\[22\] sky130_fd_sc_hd__dfxtp_1
X_4993_ net1167 _2543_ _2540_ VGND VGND VPWR VPWR _2546_ sky130_fd_sc_hd__and3_1
X_6732_ net33 _3414_ VGND VGND VPWR VPWR _3420_ sky130_fd_sc_hd__and2_1
XFILLER_0_105_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3944_ _1626_ _1627_ _1472_ VGND VGND VPWR VPWR _1628_ sky130_fd_sc_hd__mux2_1
XFILLER_0_92_219 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6663_ _2663_ _3382_ _3383_ net287 VGND VGND VPWR VPWR _0349_ sky130_fd_sc_hd__a22o_1
XFILLER_0_116_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3875_ memory\[0\]\[18\] memory\[1\]\[18\] memory\[2\]\[18\] memory\[3\]\[18\] _1271_
+ _1272_ VGND VGND VPWR VPWR _1563_ sky130_fd_sc_hd__mux4_1
XFILLER_0_58_496 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_14_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_116_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5614_ net826 _2811_ _2816_ _2818_ VGND VGND VPWR VPWR _0858_ sky130_fd_sc_hd__a31o_1
XFILLER_0_61_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_500 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_14_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6594_ _2607_ _3368_ _3370_ net298 VGND VGND VPWR VPWR _0293_ sky130_fd_sc_hd__a22o_1
X_5476_ _2480_ _2772_ _2773_ net383 VGND VGND VPWR VPWR _0797_ sky130_fd_sc_hd__a22o_1
XFILLER_0_76_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_41_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4427_ _2087_ _2088_ _1903_ VGND VGND VPWR VPWR _2089_ sky130_fd_sc_hd__mux2_1
X_7215_ clknet_leaf_7_clk _0806_ VGND VGND VPWR VPWR memory\[31\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_7146_ clknet_leaf_63_clk _0737_ VGND VGND VPWR VPWR memory\[3\]\[27\] sky130_fd_sc_hd__dfxtp_1
X_4358_ _1876_ _2023_ _1880_ VGND VGND VPWR VPWR _2024_ sky130_fd_sc_hd__o21a_1
XTAP_260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7077_ clknet_leaf_62_clk _0668_ VGND VGND VPWR VPWR memory\[4\]\[22\] sky130_fd_sc_hd__dfxtp_1
X_4289_ _1947_ _1957_ VGND VGND VPWR VPWR _1958_ sky130_fd_sc_hd__and2_1
XTAP_282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6028_ net886 _3047_ _3051_ _3057_ VGND VGND VPWR VPWR _1065_ sky130_fd_sc_hd__a31o_1
XFILLER_0_68_205 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_96_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_122_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_102_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_102_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_99_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_75_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_83_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3660_ _1177_ _1357_ _1181_ VGND VGND VPWR VPWR _1358_ sky130_fd_sc_hd__o21a_1
XFILLER_0_42_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3591_ _1236_ _1288_ _1290_ _1292_ _1208_ VGND VGND VPWR VPWR _1293_ sky130_fd_sc_hd__a221o_1
X_5330_ _2458_ _2739_ _2741_ net253 VGND VGND VPWR VPWR _0683_ sky130_fd_sc_hd__a22o_1
X_5261_ _2623_ _2695_ VGND VGND VPWR VPWR _2703_ sky130_fd_sc_hd__and2_1
X_4212_ memory\[20\]\[2\] memory\[21\]\[2\] memory\[22\]\[2\] memory\[23\]\[2\] _1800_
+ _1802_ VGND VGND VPWR VPWR _1884_ sky130_fd_sc_hd__mux4_1
X_7000_ clknet_leaf_2_clk _0591_ VGND VGND VPWR VPWR memory\[26\]\[9\] sky130_fd_sc_hd__dfxtp_1
X_5192_ _2600_ VGND VGND VPWR VPWR _2675_ sky130_fd_sc_hd__buf_4
X_4143_ memory\[24\]\[0\] memory\[25\]\[0\] memory\[26\]\[0\] memory\[27\]\[0\] _1814_
+ _1816_ VGND VGND VPWR VPWR _1817_ sky130_fd_sc_hd__mux4_1
X_4074_ _1591_ _1750_ _1595_ VGND VGND VPWR VPWR _1751_ sky130_fd_sc_hd__o21a_1
X_7902_ clknet_leaf_90_clk _0436_ VGND VGND VPWR VPWR memory\[17\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_116_61 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_78_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7833_ clknet_leaf_77_clk _0367_ VGND VGND VPWR VPWR memory\[9\]\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_19_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7764_ clknet_leaf_4_clk _0298_ VGND VGND VPWR VPWR memory\[30\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_6715_ net353 _3406_ _3400_ _3410_ VGND VGND VPWR VPWR _0374_ sky130_fd_sc_hd__a31o_1
X_4976_ net1150 _2530_ _2526_ VGND VGND VPWR VPWR _2536_ sky130_fd_sc_hd__and3_1
X_3927_ memory\[24\]\[21\] memory\[25\]\[21\] memory\[26\]\[21\] memory\[27\]\[21\]
+ _1551_ _1552_ VGND VGND VPWR VPWR _1612_ sky130_fd_sc_hd__mux4_1
X_7695_ clknet_leaf_108_clk _0229_ VGND VGND VPWR VPWR memory\[5\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_5537__14 clknet_1_0__leaf__2784_ VGND VGND VPWR VPWR net159 sky130_fd_sc_hd__inv_2
X_6646_ _3378_ VGND VGND VPWR VPWR _3381_ sky130_fd_sc_hd__clkbuf_4
X_3858_ memory\[20\]\[18\] memory\[21\]\[18\] memory\[22\]\[18\] memory\[23\]\[18\]
+ _1509_ _1510_ VGND VGND VPWR VPWR _1546_ sky130_fd_sc_hd__mux4_1
XFILLER_0_104_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6577_ _2895_ _3352_ VGND VGND VPWR VPWR _3360_ sky130_fd_sc_hd__and2_1
X_3789_ memory\[0\]\[14\] memory\[1\]\[14\] memory\[2\]\[14\] memory\[3\]\[14\] _1363_
+ _1364_ VGND VGND VPWR VPWR _1481_ sky130_fd_sc_hd__mux4_1
XFILLER_0_61_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5459_ _2766_ VGND VGND VPWR VPWR _2770_ sky130_fd_sc_hd__clkbuf_4
X_7129_ clknet_leaf_80_clk _0720_ VGND VGND VPWR VPWR memory\[3\]\[10\] sky130_fd_sc_hd__dfxtp_1
XTAP_1223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_107_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_92_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_122_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_107_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_99_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4830_ net47 VGND VGND VPWR VPWR _2462_ sky130_fd_sc_hd__clkbuf_8
XTAP_1790 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4761_ memory\[20\]\[30\] memory\[21\]\[30\] memory\[22\]\[30\] memory\[23\]\[30\]
+ _1866_ _1867_ VGND VGND VPWR VPWR _2405_ sky130_fd_sc_hd__mux4_1
XFILLER_0_7_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4692_ _1836_ _2339_ _1840_ VGND VGND VPWR VPWR _2340_ sky130_fd_sc_hd__o21a_1
X_6500_ _2895_ _3308_ VGND VGND VPWR VPWR _3315_ sky130_fd_sc_hd__and2_1
XFILLER_0_71_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7480_ clknet_leaf_112_clk _1039_ VGND VGND VPWR VPWR memory\[24\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_28_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3712_ memory\[8\]\[10\] memory\[9\]\[10\] memory\[10\]\[10\] memory\[11\]\[10\]
+ _1246_ _1247_ VGND VGND VPWR VPWR _1408_ sky130_fd_sc_hd__mux4_1
XFILLER_0_102_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6431_ net800 _3262_ _3263_ _3274_ VGND VGND VPWR VPWR _0226_ sky130_fd_sc_hd__a31o_1
X_3643_ memory\[8\]\[7\] memory\[9\]\[7\] memory\[10\]\[7\] memory\[11\]\[7\] _1246_
+ _1247_ VGND VGND VPWR VPWR _1342_ sky130_fd_sc_hd__mux4_1
XFILLER_0_113_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6362_ _3234_ VGND VGND VPWR VPWR _3235_ sky130_fd_sc_hd__buf_4
X_5313_ _2673_ _2721_ VGND VGND VPWR VPWR _2733_ sky130_fd_sc_hd__and2_1
XFILLER_0_11_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3574_ _1276_ VGND VGND VPWR VPWR _0025_ sky130_fd_sc_hd__buf_1
X_6293_ _3183_ VGND VGND VPWR VPWR _3210_ sky130_fd_sc_hd__buf_2
XFILLER_0_87_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5244_ _2692_ VGND VGND VPWR VPWR _2693_ sky130_fd_sc_hd__clkbuf_4
Xhold18 memory\[15\]\[22\] VGND VGND VPWR VPWR net227 sky130_fd_sc_hd__dlygate4sd3_1
X_5175_ _2663_ _2655_ VGND VGND VPWR VPWR _2664_ sky130_fd_sc_hd__and2_1
Xhold29 memory\[29\]\[17\] VGND VGND VPWR VPWR net238 sky130_fd_sc_hd__dlygate4sd3_1
X_4126_ _1799_ VGND VGND VPWR VPWR _1800_ sky130_fd_sc_hd__buf_6
XFILLER_0_39_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4057_ _1584_ _1730_ _1732_ _1734_ _1597_ VGND VGND VPWR VPWR _1735_ sky130_fd_sc_hd__a221o_1
XFILLER_0_78_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7816_ clknet_leaf_58_clk _0350_ VGND VGND VPWR VPWR memory\[12\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_78_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_66_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7747_ clknet_leaf_25_clk _0281_ VGND VGND VPWR VPWR memory\[22\]\[20\] sky130_fd_sc_hd__dfxtp_1
X_4959_ _2512_ VGND VGND VPWR VPWR _2526_ sky130_fd_sc_hd__buf_2
XFILLER_0_117_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7678_ clknet_leaf_94_clk _0212_ VGND VGND VPWR VPWR memory\[21\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_117_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6629_ _2678_ _3367_ _3369_ net754 VGND VGND VPWR VPWR _0324_ sky130_fd_sc_hd__a22o_1
XFILLER_0_61_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_96_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1031 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1020 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1064 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1053 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1042 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_84_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1097 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1086 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1075 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_108_674 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_107_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_804 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_815 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_826 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_837 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_848 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_859 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6980_ clknet_leaf_62_clk _0571_ VGND VGND VPWR VPWR memory\[6\]\[21\] sky130_fd_sc_hd__dfxtp_1
X_5931_ net432 _2994_ _2990_ _3000_ VGND VGND VPWR VPWR _1025_ sky130_fd_sc_hd__a31o_1
XFILLER_0_48_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_87_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5862_ _2488_ _2918_ _2959_ VGND VGND VPWR VPWR _0965_ sky130_fd_sc_hd__a21o_1
X_7601_ clknet_leaf_0_clk _0135_ VGND VGND VPWR VPWR memory\[27\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_5793_ memory\[25\]\[0\] _2597_ _2921_ VGND VGND VPWR VPWR _2922_ sky130_fd_sc_hd__and3_1
X_4813_ _2439_ _2449_ _2453_ net545 VGND VGND VPWR VPWR _0453_ sky130_fd_sc_hd__a22o_1
XFILLER_0_113_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7532_ clknet_leaf_50_clk _1091_ VGND VGND VPWR VPWR memory\[11\]\[29\] sky130_fd_sc_hd__dfxtp_1
X_4744_ _1871_ _2388_ VGND VGND VPWR VPWR _2389_ sky130_fd_sc_hd__or2_1
XFILLER_0_8_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_44_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7463_ clknet_leaf_61_clk _1022_ VGND VGND VPWR VPWR memory\[1\]\[24\] sky130_fd_sc_hd__dfxtp_1
X_4675_ _2113_ _2323_ VGND VGND VPWR VPWR _2324_ sky130_fd_sc_hd__or2_1
X_6414_ _2884_ _3264_ VGND VGND VPWR VPWR _3266_ sky130_fd_sc_hd__and2_1
X_3626_ memory\[4\]\[6\] memory\[5\]\[6\] memory\[6\]\[6\] memory\[7\]\[6\] _1199_
+ _1200_ VGND VGND VPWR VPWR _1326_ sky130_fd_sc_hd__mux4_1
XFILLER_0_31_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7394_ clknet_leaf_99_clk _0953_ VGND VGND VPWR VPWR memory\[25\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_113_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3557_ _1258_ _1259_ _1166_ VGND VGND VPWR VPWR _1260_ sky130_fd_sc_hd__mux2_1
X_6345_ _2650_ _3229_ _3230_ net232 VGND VGND VPWR VPWR _0184_ sky130_fd_sc_hd__a22o_1
X_6276_ _2863_ _3197_ VGND VGND VPWR VPWR _3201_ sky130_fd_sc_hd__and2_1
X_5227_ _2682_ VGND VGND VPWR VPWR _2688_ sky130_fd_sc_hd__clkbuf_4
X_3488_ _1187_ VGND VGND VPWR VPWR _1194_ sky130_fd_sc_hd__buf_6
X_5158_ net533 _2629_ _2630_ _2651_ VGND VGND VPWR VPWR _0601_ sky130_fd_sc_hd__a31o_1
X_5089_ net13 net14 net15 VGND VGND VPWR VPWR _2602_ sky130_fd_sc_hd__and3b_1
X_4109_ memory\[28\]\[31\] memory\[29\]\[31\] memory\[30\]\[31\] memory\[31\]\[31\]
+ _1171_ _1173_ VGND VGND VPWR VPWR _1784_ sky130_fd_sc_hd__mux4_1
XFILLER_0_94_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_678 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_109_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_92 net108 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_70 net63 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_81 net81 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_120_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_120_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_30_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_118_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_27_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_53_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold307 memory\[12\]\[29\] VGND VGND VPWR VPWR net516 sky130_fd_sc_hd__dlygate4sd3_1
X_4460_ memory\[8\]\[13\] memory\[9\]\[13\] memory\[10\]\[13\] memory\[11\]\[13\]
+ _1948_ _1949_ VGND VGND VPWR VPWR _2121_ sky130_fd_sc_hd__mux4_1
XFILLER_0_7_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_13_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold329 memory\[29\]\[6\] VGND VGND VPWR VPWR net538 sky130_fd_sc_hd__dlygate4sd3_1
X_4391_ _1812_ _2054_ VGND VGND VPWR VPWR _2055_ sky130_fd_sc_hd__or2_1
Xhold318 memory\[7\]\[14\] VGND VGND VPWR VPWR net527 sky130_fd_sc_hd__dlygate4sd3_1
X_6130_ _2870_ _3110_ VGND VGND VPWR VPWR _3116_ sky130_fd_sc_hd__and2_1
XTAP_612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6061_ _2876_ _3066_ VGND VGND VPWR VPWR _3076_ sky130_fd_sc_hd__and2_1
XTAP_645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5012_ _2529_ VGND VGND VPWR VPWR _2557_ sky130_fd_sc_hd__buf_2
X_6963_ clknet_leaf_105_clk _0554_ VGND VGND VPWR VPWR memory\[6\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_5914_ _2964_ VGND VGND VPWR VPWR _2991_ sky130_fd_sc_hd__buf_2
X_6894_ clknet_leaf_19_clk _0485_ VGND VGND VPWR VPWR memory\[15\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_5845_ net1121 _2943_ _2947_ VGND VGND VPWR VPWR _2951_ sky130_fd_sc_hd__and3_1
XFILLER_0_29_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5776_ _2654_ _2915_ _2916_ net468 VGND VGND VPWR VPWR _0922_ sky130_fd_sc_hd__a22o_1
XFILLER_0_90_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_8_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4727_ _2371_ _2372_ _1819_ VGND VGND VPWR VPWR _2373_ sky130_fd_sc_hd__mux2_1
XFILLER_0_44_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7515_ clknet_leaf_77_clk _1074_ VGND VGND VPWR VPWR memory\[11\]\[12\] sky130_fd_sc_hd__dfxtp_1
X_4658_ memory\[28\]\[24\] memory\[29\]\[24\] memory\[30\]\[24\] memory\[31\]\[24\]
+ _2092_ _2093_ VGND VGND VPWR VPWR _2308_ sky130_fd_sc_hd__mux4_1
XFILLER_0_71_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7446_ clknet_leaf_107_clk _1005_ VGND VGND VPWR VPWR memory\[1\]\[7\] sky130_fd_sc_hd__dfxtp_1
Xhold830 memory\[19\]\[6\] VGND VGND VPWR VPWR net1039 sky130_fd_sc_hd__dlygate4sd3_1
X_3609_ _1236_ _1305_ _1307_ _1309_ _1208_ VGND VGND VPWR VPWR _1310_ sky130_fd_sc_hd__a221o_1
Xhold852 memory\[4\]\[27\] VGND VGND VPWR VPWR net1061 sky130_fd_sc_hd__dlygate4sd3_1
X_4589_ memory\[0\]\[20\] memory\[1\]\[20\] memory\[2\]\[20\] memory\[3\]\[20\] _2017_
+ _2018_ VGND VGND VPWR VPWR _2243_ sky130_fd_sc_hd__mux4_1
Xhold841 memory\[20\]\[6\] VGND VGND VPWR VPWR net1050 sky130_fd_sc_hd__dlygate4sd3_1
Xhold863 memory\[26\]\[12\] VGND VGND VPWR VPWR net1072 sky130_fd_sc_hd__dlygate4sd3_1
X_7377_ clknet_leaf_4_clk _0936_ VGND VGND VPWR VPWR memory\[25\]\[2\] sky130_fd_sc_hd__dfxtp_1
Xhold885 memory\[4\]\[28\] VGND VGND VPWR VPWR net1094 sky130_fd_sc_hd__dlygate4sd3_1
X_6328_ _2617_ _3226_ _3228_ net428 VGND VGND VPWR VPWR _0169_ sky130_fd_sc_hd__a22o_1
Xhold874 memory\[5\]\[4\] VGND VGND VPWR VPWR net1083 sky130_fd_sc_hd__dlygate4sd3_1
Xhold896 memory\[6\]\[4\] VGND VGND VPWR VPWR net1105 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_110_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6259_ _2847_ _3184_ VGND VGND VPWR VPWR _3191_ sky130_fd_sc_hd__and2_1
XFILLER_0_99_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_67_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_303 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_66_122 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_47_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_269 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6837__45 clknet_1_1__leaf__3445_ VGND VGND VPWR VPWR net190 sky130_fd_sc_hd__inv_2
XFILLER_0_100_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6852__59 clknet_1_0__leaf__3446_ VGND VGND VPWR VPWR net204 sky130_fd_sc_hd__inv_2
XFILLER_0_89_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3960_ memory\[20\]\[23\] memory\[21\]\[23\] memory\[22\]\[23\] memory\[23\]\[23\]
+ _1509_ _1510_ VGND VGND VPWR VPWR _1643_ sky130_fd_sc_hd__mux4_1
XFILLER_0_58_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3891_ memory\[8\]\[19\] memory\[9\]\[19\] memory\[10\]\[19\] memory\[11\]\[19\]
+ _1426_ _1427_ VGND VGND VPWR VPWR _1578_ sky130_fd_sc_hd__mux4_1
X_5630_ _2671_ _2817_ VGND VGND VPWR VPWR _2827_ sky130_fd_sc_hd__and2_1
XFILLER_0_73_659 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_70_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_7300_ clknet_leaf_53_clk _0859_ VGND VGND VPWR VPWR memory\[8\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_81_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4512_ _2116_ _2169_ _2118_ VGND VGND VPWR VPWR _2170_ sky130_fd_sc_hd__o21a_1
X_5492_ _2613_ _2776_ _2778_ net486 VGND VGND VPWR VPWR _0808_ sky130_fd_sc_hd__a22o_1
XFILLER_0_53_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_110_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold104 memory\[29\]\[31\] VGND VGND VPWR VPWR net313 sky130_fd_sc_hd__dlygate4sd3_1
X_7231_ clknet_leaf_86_clk _0822_ VGND VGND VPWR VPWR memory\[31\]\[16\] sky130_fd_sc_hd__dfxtp_1
Xhold126 memory\[4\]\[9\] VGND VGND VPWR VPWR net335 sky130_fd_sc_hd__dlygate4sd3_1
Xhold115 memory\[2\]\[8\] VGND VGND VPWR VPWR net324 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_111_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_110_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold137 memory\[8\]\[24\] VGND VGND VPWR VPWR net346 sky130_fd_sc_hd__dlygate4sd3_1
X_4443_ memory\[12\]\[12\] memory\[13\]\[12\] memory\[14\]\[12\] memory\[15\]\[12\]
+ _2045_ _2046_ VGND VGND VPWR VPWR _2105_ sky130_fd_sc_hd__mux4_1
Xhold148 memory\[12\]\[11\] VGND VGND VPWR VPWR net357 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_1_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold159 memory\[29\]\[4\] VGND VGND VPWR VPWR net368 sky130_fd_sc_hd__dlygate4sd3_1
X_4374_ _1798_ _2031_ _2035_ _2037_ _2038_ VGND VGND VPWR VPWR _2039_ sky130_fd_sc_hd__a221o_1
X_7162_ clknet_leaf_82_clk _0753_ VGND VGND VPWR VPWR memory\[2\]\[11\] sky130_fd_sc_hd__dfxtp_1
X_7093_ clknet_leaf_7_clk _0684_ VGND VGND VPWR VPWR memory\[29\]\[6\] sky130_fd_sc_hd__dfxtp_1
XTAP_431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6113_ net1046 _3104_ _3095_ _3106_ VGND VGND VPWR VPWR _1101_ sky130_fd_sc_hd__a31o_1
XFILLER_0_1_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6044_ _2858_ _3066_ VGND VGND VPWR VPWR _3067_ sky130_fd_sc_hd__and2_1
XTAP_486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6946_ clknet_leaf_72_clk _0537_ VGND VGND VPWR VPWR memory\[10\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_76_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6877_ clknet_leaf_87_clk _0468_ VGND VGND VPWR VPWR memory\[28\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_36_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_48_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_119_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5828_ memory\[25\]\[16\] _2930_ _2934_ VGND VGND VPWR VPWR _2941_ sky130_fd_sc_hd__and3_1
X_5759_ _2623_ _2910_ _2912_ net695 VGND VGND VPWR VPWR _0909_ sky130_fd_sc_hd__a22o_1
XFILLER_0_17_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7429_ clknet_leaf_65_clk net123 VGND VGND VPWR VPWR memory\[0\]\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_32_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold660 memory\[27\]\[4\] VGND VGND VPWR VPWR net869 sky130_fd_sc_hd__dlygate4sd3_1
Xhold671 memory\[5\]\[12\] VGND VGND VPWR VPWR net880 sky130_fd_sc_hd__dlygate4sd3_1
Xhold682 memory\[26\]\[27\] VGND VGND VPWR VPWR net891 sky130_fd_sc_hd__dlygate4sd3_1
Xhold693 memory\[23\]\[31\] VGND VGND VPWR VPWR net902 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_99_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_82_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_113_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_23_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_120_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4090_ _1245_ _1765_ VGND VGND VPWR VPWR _1766_ sky130_fd_sc_hd__or2_1
XFILLER_0_77_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6800_ _2625_ _3438_ _3440_ net296 VGND VGND VPWR VPWR _0429_ sky130_fd_sc_hd__a22o_1
X_7780_ clknet_leaf_36_clk _0314_ VGND VGND VPWR VPWR memory\[30\]\[21\] sky130_fd_sc_hd__dfxtp_1
X_4992_ _2480_ _2539_ _2545_ VGND VGND VPWR VPWR _0541_ sky130_fd_sc_hd__a21o_1
X_6731_ net354 _2509_ _3413_ _3419_ VGND VGND VPWR VPWR _0381_ sky130_fd_sc_hd__a31o_1
X_3943_ memory\[16\]\[22\] memory\[17\]\[22\] memory\[18\]\[22\] memory\[19\]\[22\]
+ _1547_ _1548_ VGND VGND VPWR VPWR _1627_ sky130_fd_sc_hd__mux4_1
XFILLER_0_14_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6662_ _2661_ _3382_ _3383_ net213 VGND VGND VPWR VPWR _0348_ sky130_fd_sc_hd__a22o_1
X_3874_ memory\[4\]\[18\] memory\[5\]\[18\] memory\[6\]\[18\] memory\[7\]\[18\] _1199_
+ _1200_ VGND VGND VPWR VPWR _1562_ sky130_fd_sc_hd__mux4_1
XFILLER_0_6_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5613_ _2654_ _2817_ VGND VGND VPWR VPWR _2818_ sky130_fd_sc_hd__and2_1
X_6593_ _3369_ VGND VGND VPWR VPWR _3370_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_14_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5475_ _2479_ _2772_ _2773_ net246 VGND VGND VPWR VPWR _0796_ sky130_fd_sc_hd__a22o_1
XFILLER_0_111_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7214_ clknet_leaf_15_clk _0805_ VGND VGND VPWR VPWR memory\[14\]\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_69_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4426_ memory\[16\]\[12\] memory\[17\]\[12\] memory\[18\]\[12\] memory\[19\]\[12\]
+ _2028_ _2029_ VGND VGND VPWR VPWR _2088_ sky130_fd_sc_hd__mux4_1
XFILLER_0_1_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_41_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7145_ clknet_leaf_63_clk _0736_ VGND VGND VPWR VPWR memory\[3\]\[26\] sky130_fd_sc_hd__dfxtp_1
X_4357_ memory\[12\]\[8\] memory\[13\]\[8\] memory\[14\]\[8\] memory\[15\]\[8\] _1877_
+ _1878_ VGND VGND VPWR VPWR _2023_ sky130_fd_sc_hd__mux4_2
XTAP_250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7076_ clknet_leaf_62_clk _0667_ VGND VGND VPWR VPWR memory\[4\]\[21\] sky130_fd_sc_hd__dfxtp_1
X_4288_ _1951_ _1953_ _1956_ _1850_ _1851_ VGND VGND VPWR VPWR _1957_ sky130_fd_sc_hd__a221o_1
XTAP_272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6027_ _2842_ _3053_ VGND VGND VPWR VPWR _3057_ sky130_fd_sc_hd__and2_1
XTAP_294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_119_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6929_ clknet_leaf_8_clk _0520_ VGND VGND VPWR VPWR memory\[10\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_119_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_107_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_618 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_103_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold490 memory\[15\]\[18\] VGND VGND VPWR VPWR net699 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_19_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_55_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3590_ _1250_ _1291_ _1254_ VGND VGND VPWR VPWR _1292_ sky130_fd_sc_hd__o21a_1
XFILLER_0_23_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5260_ net742 _2675_ _2693_ _2702_ VGND VGND VPWR VPWR _0652_ sky130_fd_sc_hd__a31o_1
XFILLER_0_50_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_121_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4211_ _1883_ VGND VGND VPWR VPWR _0043_ sky130_fd_sc_hd__clkbuf_1
X_5191_ net945 _2652_ _2653_ _2674_ VGND VGND VPWR VPWR _0611_ sky130_fd_sc_hd__a31o_1
X_4142_ _1815_ VGND VGND VPWR VPWR _1816_ sky130_fd_sc_hd__buf_4
X_4073_ memory\[28\]\[29\] memory\[29\]\[29\] memory\[30\]\[29\] memory\[31\]\[29\]
+ _1592_ _1593_ VGND VGND VPWR VPWR _1750_ sky130_fd_sc_hd__mux4_1
X_7901_ clknet_leaf_88_clk _0435_ VGND VGND VPWR VPWR memory\[17\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_116_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7832_ clknet_leaf_13_clk _0366_ VGND VGND VPWR VPWR memory\[9\]\[9\] sky130_fd_sc_hd__dfxtp_1
X_4975_ _2471_ _2525_ _2535_ VGND VGND VPWR VPWR _0534_ sky130_fd_sc_hd__a21o_1
XFILLER_0_58_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7763_ clknet_leaf_4_clk _0297_ VGND VGND VPWR VPWR memory\[30\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_3926_ _1609_ _1610_ _1472_ VGND VGND VPWR VPWR _1611_ sky130_fd_sc_hd__mux2_1
XFILLER_0_74_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6714_ net24 _3401_ VGND VGND VPWR VPWR _3410_ sky130_fd_sc_hd__and2_1
X_7694_ clknet_leaf_9_clk _0228_ VGND VGND VPWR VPWR memory\[21\]\[31\] sky130_fd_sc_hd__dfxtp_1
X_6645_ _3376_ VGND VGND VPWR VPWR _3380_ sky130_fd_sc_hd__clkbuf_4
X_3857_ _1545_ VGND VGND VPWR VPWR _0008_ sky130_fd_sc_hd__clkbuf_1
X_6576_ _2508_ VGND VGND VPWR VPWR _3359_ sky130_fd_sc_hd__buf_4
XFILLER_0_73_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3788_ memory\[4\]\[14\] memory\[5\]\[14\] memory\[6\]\[14\] memory\[7\]\[14\] _1360_
+ _1361_ VGND VGND VPWR VPWR _1480_ sky130_fd_sc_hd__mux4_1
X_5527_ clknet_1_0__leaf__2783_ VGND VGND VPWR VPWR _2784_ sky130_fd_sc_hd__buf_1
XFILLER_0_14_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5458_ _2462_ _2767_ _2769_ net1021 VGND VGND VPWR VPWR _0783_ sky130_fd_sc_hd__a22o_1
X_5389_ _2748_ VGND VGND VPWR VPWR _2754_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4409_ _1964_ _2071_ _1968_ VGND VGND VPWR VPWR _2072_ sky130_fd_sc_hd__o21a_1
X_7128_ clknet_leaf_102_clk _0719_ VGND VGND VPWR VPWR memory\[3\]\[9\] sky130_fd_sc_hd__dfxtp_1
X_7059_ clknet_leaf_112_clk _0650_ VGND VGND VPWR VPWR memory\[4\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_96_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_122_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_103_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_20_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_46_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_1_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_75_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1791 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_117_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1780 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4760_ _2404_ VGND VGND VPWR VPWR _0053_ sky130_fd_sc_hd__buf_1
X_4691_ memory\[28\]\[26\] memory\[29\]\[26\] memory\[30\]\[26\] memory\[31\]\[26\]
+ _1960_ _1961_ VGND VGND VPWR VPWR _2339_ sky130_fd_sc_hd__mux4_1
XFILLER_0_55_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3711_ _1405_ _1406_ _1243_ VGND VGND VPWR VPWR _1407_ sky130_fd_sc_hd__mux2_1
X_6430_ _2901_ _3264_ VGND VGND VPWR VPWR _3274_ sky130_fd_sc_hd__and2_1
XFILLER_0_11_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3642_ _1339_ _1340_ _1243_ VGND VGND VPWR VPWR _1341_ sky130_fd_sc_hd__mux2_1
XFILLER_0_102_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6361_ _2960_ _3093_ VGND VGND VPWR VPWR _3234_ sky130_fd_sc_hd__or2b_1
X_5312_ net1094 _2731_ _2720_ _2732_ VGND VGND VPWR VPWR _0674_ sky130_fd_sc_hd__a31o_1
X_3573_ _1265_ _1275_ VGND VGND VPWR VPWR _1276_ sky130_fd_sc_hd__and2_1
X_6292_ _3181_ VGND VGND VPWR VPWR _3209_ sky130_fd_sc_hd__clkbuf_4
X_5243_ _2691_ _2558_ VGND VGND VPWR VPWR _2692_ sky130_fd_sc_hd__nand2_4
XFILLER_0_11_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5174_ net32 VGND VGND VPWR VPWR _2663_ sky130_fd_sc_hd__buf_4
Xhold19 memory\[29\]\[3\] VGND VGND VPWR VPWR net228 sky130_fd_sc_hd__dlygate4sd3_1
X_4125_ net1 VGND VGND VPWR VPWR _1799_ sky130_fd_sc_hd__clkbuf_8
X_4056_ _1591_ _1733_ _1595_ VGND VGND VPWR VPWR _1734_ sky130_fd_sc_hd__o21a_1
X_7815_ clknet_leaf_53_clk _0349_ VGND VGND VPWR VPWR memory\[12\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_93_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_66_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4958_ _2504_ VGND VGND VPWR VPWR _2525_ sky130_fd_sc_hd__clkbuf_4
X_7746_ clknet_leaf_108_clk _0280_ VGND VGND VPWR VPWR memory\[22\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_46_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3909_ _1153_ VGND VGND VPWR VPWR _1595_ sky130_fd_sc_hd__buf_2
X_4889_ _2454_ _2494_ _2496_ net887 VGND VGND VPWR VPWR _0486_ sky130_fd_sc_hd__a22o_1
X_7677_ clknet_leaf_109_clk _0211_ VGND VGND VPWR VPWR memory\[21\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_46_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_116_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6628_ _2676_ _3367_ _3369_ net514 VGND VGND VPWR VPWR _0323_ sky130_fd_sc_hd__a22o_1
XFILLER_0_6_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_117_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_61_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6559_ net962 _3346_ _3338_ _3349_ VGND VGND VPWR VPWR _0279_ sky130_fd_sc_hd__a31o_1
XFILLER_0_112_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_100_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1021 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1010 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1065 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1054 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1032 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1043 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1098 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1087 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1076 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_108_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_108_686 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_4_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_805 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_816 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_827 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_838 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_849 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5930_ _2897_ _2991_ VGND VGND VPWR VPWR _3000_ sky130_fd_sc_hd__and2_1
XFILLER_0_73_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5861_ memory\[25\]\[31\] _2600_ _2920_ VGND VGND VPWR VPWR _2959_ sky130_fd_sc_hd__and3_1
X_7600_ clknet_leaf_3_clk _0134_ VGND VGND VPWR VPWR memory\[27\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_4812_ _2452_ VGND VGND VPWR VPWR _2453_ sky130_fd_sc_hd__clkbuf_4
X_5792_ _2920_ VGND VGND VPWR VPWR _2921_ sky130_fd_sc_hd__buf_2
X_7531_ clknet_leaf_38_clk _1090_ VGND VGND VPWR VPWR memory\[11\]\[28\] sky130_fd_sc_hd__dfxtp_1
X_4743_ memory\[24\]\[29\] memory\[25\]\[29\] memory\[26\]\[29\] memory\[27\]\[29\]
+ _1872_ _1873_ VGND VGND VPWR VPWR _2388_ sky130_fd_sc_hd__mux4_1
XFILLER_0_90_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7462_ clknet_leaf_61_clk _1021_ VGND VGND VPWR VPWR memory\[1\]\[23\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_22_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_114_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_113_100 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4674_ memory\[24\]\[25\] memory\[25\]\[25\] memory\[26\]\[25\] memory\[27\]\[25\]
+ _1877_ _1878_ VGND VGND VPWR VPWR _2323_ sky130_fd_sc_hd__mux4_2
X_6413_ net829 _3262_ _3263_ _3265_ VGND VGND VPWR VPWR _0217_ sky130_fd_sc_hd__a31o_1
X_3625_ _1193_ _1324_ _1197_ VGND VGND VPWR VPWR _1325_ sky130_fd_sc_hd__o21a_1
X_7393_ clknet_leaf_100_clk _0952_ VGND VGND VPWR VPWR memory\[25\]\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_113_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_101_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3556_ memory\[16\]\[3\] memory\[17\]\[3\] memory\[18\]\[3\] memory\[19\]\[3\] _1161_
+ _1162_ VGND VGND VPWR VPWR _1259_ sky130_fd_sc_hd__mux4_1
X_6344_ _2648_ _3229_ _3230_ net768 VGND VGND VPWR VPWR _0183_ sky130_fd_sc_hd__a22o_1
XFILLER_0_11_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6275_ _3145_ VGND VGND VPWR VPWR _3200_ sky130_fd_sc_hd__clkbuf_8
X_3487_ _1165_ VGND VGND VPWR VPWR _1193_ sky130_fd_sc_hd__buf_4
X_5226_ _2474_ _2686_ _2687_ net461 VGND VGND VPWR VPWR _0633_ sky130_fd_sc_hd__a22o_1
XFILLER_0_51_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5157_ _2650_ _2632_ VGND VGND VPWR VPWR _2651_ sky130_fd_sc_hd__and2_1
XFILLER_0_98_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4108_ _1245_ _1782_ VGND VGND VPWR VPWR _1783_ sky130_fd_sc_hd__or2_1
X_5088_ _2600_ VGND VGND VPWR VPWR _2601_ sky130_fd_sc_hd__clkbuf_4
X_4039_ _1584_ _1713_ _1715_ _1717_ _1597_ VGND VGND VPWR VPWR _1718_ sky130_fd_sc_hd__a221o_1
XPHY_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_307 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7729_ clknet_leaf_115_clk _0263_ VGND VGND VPWR VPWR memory\[22\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_105_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_leaf_113_clk clknet_4_0_0_clk VGND VGND VPWR VPWR clknet_leaf_113_clk sky130_fd_sc_hd__clkbuf_16
XANTENNA_93 net109 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_82 net84 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_71 net64 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_60 _3369_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_120_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_97_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_72_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_25_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_104_clk clknet_4_3_0_clk VGND VGND VPWR VPWR clknet_leaf_104_clk sky130_fd_sc_hd__clkbuf_16
Xhold308 memory\[20\]\[1\] VGND VGND VPWR VPWR net517 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_7_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_41_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_111_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold319 memory\[19\]\[30\] VGND VGND VPWR VPWR net528 sky130_fd_sc_hd__dlygate4sd3_1
X_4390_ memory\[24\]\[10\] memory\[25\]\[10\] memory\[26\]\[10\] memory\[27\]\[10\]
+ _2032_ _2033_ VGND VGND VPWR VPWR _2054_ sky130_fd_sc_hd__mux4_1
XFILLER_0_0_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6060_ _3005_ VGND VGND VPWR VPWR _3075_ sky130_fd_sc_hd__buf_4
XTAP_635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5011_ _2555_ VGND VGND VPWR VPWR _2556_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_108_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6962_ clknet_leaf_103_clk _0553_ VGND VGND VPWR VPWR memory\[6\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_5913_ _2962_ VGND VGND VPWR VPWR _2990_ sky130_fd_sc_hd__clkbuf_4
X_6893_ clknet_leaf_18_clk _0484_ VGND VGND VPWR VPWR memory\[28\]\[31\] sky130_fd_sc_hd__dfxtp_1
X_5844_ _2479_ _2946_ _2950_ VGND VGND VPWR VPWR _0956_ sky130_fd_sc_hd__a21o_1
XFILLER_0_75_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_702 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5775_ _2911_ VGND VGND VPWR VPWR _2916_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_90_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7514_ clknet_leaf_74_clk _1073_ VGND VGND VPWR VPWR memory\[11\]\[11\] sky130_fd_sc_hd__dfxtp_1
X_4726_ memory\[16\]\[28\] memory\[17\]\[28\] memory\[18\]\[28\] memory\[19\]\[28\]
+ _1800_ _1802_ VGND VGND VPWR VPWR _2372_ sky130_fd_sc_hd__mux4_1
X_4657_ _2113_ _2306_ VGND VGND VPWR VPWR _2307_ sky130_fd_sc_hd__or2_1
XFILLER_0_31_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7445_ clknet_leaf_102_clk _1004_ VGND VGND VPWR VPWR memory\[1\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_3608_ _1250_ _1308_ _1254_ VGND VGND VPWR VPWR _1309_ sky130_fd_sc_hd__o21a_1
Xhold820 memory\[31\]\[12\] VGND VGND VPWR VPWR net1029 sky130_fd_sc_hd__dlygate4sd3_1
X_7376_ clknet_leaf_4_clk _0935_ VGND VGND VPWR VPWR memory\[25\]\[1\] sky130_fd_sc_hd__dfxtp_1
Xhold831 memory\[23\]\[27\] VGND VGND VPWR VPWR net1040 sky130_fd_sc_hd__dlygate4sd3_1
X_4588_ memory\[4\]\[20\] memory\[5\]\[20\] memory\[6\]\[20\] memory\[7\]\[20\] _2014_
+ _2015_ VGND VGND VPWR VPWR _2242_ sky130_fd_sc_hd__mux4_1
Xhold842 memory\[22\]\[26\] VGND VGND VPWR VPWR net1051 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_3_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold864 memory\[26\]\[11\] VGND VGND VPWR VPWR net1073 sky130_fd_sc_hd__dlygate4sd3_1
X_6327_ _2615_ _3226_ _3228_ net629 VGND VGND VPWR VPWR _0168_ sky130_fd_sc_hd__a22o_1
Xhold853 memory\[4\]\[3\] VGND VGND VPWR VPWR net1062 sky130_fd_sc_hd__dlygate4sd3_1
X_3539_ _1164_ VGND VGND VPWR VPWR _1243_ sky130_fd_sc_hd__buf_6
Xhold875 memory\[8\]\[19\] VGND VGND VPWR VPWR net1084 sky130_fd_sc_hd__dlygate4sd3_1
Xhold897 memory\[10\]\[5\] VGND VGND VPWR VPWR net1106 sky130_fd_sc_hd__dlygate4sd3_1
Xhold886 memory\[1\]\[5\] VGND VGND VPWR VPWR net1095 sky130_fd_sc_hd__dlygate4sd3_1
X_6258_ net869 _3187_ _3182_ _3190_ VGND VGND VPWR VPWR _0137_ sky130_fd_sc_hd__a31o_1
X_6189_ net448 _3146_ _3138_ _3150_ VGND VGND VPWR VPWR _1133_ sky130_fd_sc_hd__a31o_1
X_5209_ _2457_ _2683_ _2685_ net792 VGND VGND VPWR VPWR _0618_ sky130_fd_sc_hd__a22o_1
XFILLER_0_98_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_94_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_58_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3890_ _1575_ _1576_ _1521_ VGND VGND VPWR VPWR _1577_ sky130_fd_sc_hd__mux2_1
XFILLER_0_57_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5560_ clknet_1_0__leaf__2783_ VGND VGND VPWR VPWR _2787_ sky130_fd_sc_hd__buf_1
XFILLER_0_85_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4511_ memory\[28\]\[16\] memory\[29\]\[16\] memory\[30\]\[16\] memory\[31\]\[16\]
+ _2092_ _2093_ VGND VGND VPWR VPWR _2169_ sky130_fd_sc_hd__mux4_1
XFILLER_0_41_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5491_ _2611_ _2776_ _2778_ net521 VGND VGND VPWR VPWR _0807_ sky130_fd_sc_hd__a22o_1
Xhold116 memory\[18\]\[30\] VGND VGND VPWR VPWR net325 sky130_fd_sc_hd__dlygate4sd3_1
X_4442_ _1808_ VGND VGND VPWR VPWR _2104_ sky130_fd_sc_hd__clkbuf_4
X_7230_ clknet_leaf_87_clk _0821_ VGND VGND VPWR VPWR memory\[31\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_41_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold105 memory\[31\]\[0\] VGND VGND VPWR VPWR net314 sky130_fd_sc_hd__dlygate4sd3_1
Xhold138 memory\[15\]\[25\] VGND VGND VPWR VPWR net347 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_79_89 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold149 memory\[2\]\[16\] VGND VGND VPWR VPWR net358 sky130_fd_sc_hd__dlygate4sd3_1
Xhold127 memory\[2\]\[3\] VGND VGND VPWR VPWR net336 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_1_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4373_ _1826_ VGND VGND VPWR VPWR _2038_ sky130_fd_sc_hd__clkbuf_4
X_7161_ clknet_leaf_79_clk _0752_ VGND VGND VPWR VPWR memory\[2\]\[10\] sky130_fd_sc_hd__dfxtp_1
XTAP_432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6112_ _2851_ _3097_ VGND VGND VPWR VPWR _3106_ sky130_fd_sc_hd__and2_1
X_7092_ clknet_leaf_4_clk _0683_ VGND VGND VPWR VPWR memory\[29\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_119_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6043_ _3052_ VGND VGND VPWR VPWR _3066_ sky130_fd_sc_hd__buf_2
XTAP_443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_119_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6945_ clknet_leaf_73_clk _0536_ VGND VGND VPWR VPWR memory\[10\]\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_44_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_119_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_646 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_119_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6876_ clknet_leaf_78_clk _0467_ VGND VGND VPWR VPWR memory\[28\]\[14\] sky130_fd_sc_hd__dfxtp_1
X_5827_ _2470_ _2933_ _2940_ VGND VGND VPWR VPWR _0949_ sky130_fd_sc_hd__a21o_1
XFILLER_0_29_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5758_ _2621_ _2910_ _2912_ net1068 VGND VGND VPWR VPWR _0908_ sky130_fd_sc_hd__a22o_1
X_4709_ _2354_ _2355_ _1819_ VGND VGND VPWR VPWR _2356_ sky130_fd_sc_hd__mux2_1
X_7428_ clknet_leaf_61_clk net124 VGND VGND VPWR VPWR memory\[0\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_71_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5689_ net21 VGND VGND VPWR VPWR _2868_ sky130_fd_sc_hd__buf_4
Xhold650 memory\[19\]\[27\] VGND VGND VPWR VPWR net859 sky130_fd_sc_hd__dlygate4sd3_1
Xhold661 memory\[27\]\[28\] VGND VGND VPWR VPWR net870 sky130_fd_sc_hd__dlygate4sd3_1
X_7359_ clknet_leaf_90_clk _0918_ VGND VGND VPWR VPWR memory\[18\]\[16\] sky130_fd_sc_hd__dfxtp_1
Xhold672 memory\[11\]\[2\] VGND VGND VPWR VPWR net881 sky130_fd_sc_hd__dlygate4sd3_1
Xhold683 memory\[2\]\[17\] VGND VGND VPWR VPWR net892 sky130_fd_sc_hd__dlygate4sd3_1
Xhold694 memory\[13\]\[5\] VGND VGND VPWR VPWR net903 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_79_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_82_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_121_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6730_ net32 _3414_ VGND VGND VPWR VPWR _3419_ sky130_fd_sc_hd__and2_1
X_4991_ net1162 _2543_ _2540_ VGND VGND VPWR VPWR _2545_ sky130_fd_sc_hd__and3_1
X_3942_ memory\[20\]\[22\] memory\[21\]\[22\] memory\[22\]\[22\] memory\[23\]\[22\]
+ _1509_ _1510_ VGND VGND VPWR VPWR _1626_ sky130_fd_sc_hd__mux4_1
XFILLER_0_85_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_58_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6661_ _2659_ _3382_ _3383_ net290 VGND VGND VPWR VPWR _0347_ sky130_fd_sc_hd__a22o_1
XFILLER_0_85_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3873_ _1193_ _1560_ _1197_ VGND VGND VPWR VPWR _1561_ sky130_fd_sc_hd__o21a_1
X_5612_ _2790_ VGND VGND VPWR VPWR _2817_ sky130_fd_sc_hd__clkbuf_4
X_6592_ _2450_ _3367_ VGND VGND VPWR VPWR _3369_ sky130_fd_sc_hd__nor2_4
XFILLER_0_6_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_90_7 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_54_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5474_ _2478_ _2772_ _2773_ net223 VGND VGND VPWR VPWR _0795_ sky130_fd_sc_hd__a22o_1
X_7213_ clknet_leaf_40_clk _0804_ VGND VGND VPWR VPWR memory\[14\]\[30\] sky130_fd_sc_hd__dfxtp_1
X_4425_ memory\[20\]\[12\] memory\[21\]\[12\] memory\[22\]\[12\] memory\[23\]\[12\]
+ _1938_ _1939_ VGND VGND VPWR VPWR _2087_ sky130_fd_sc_hd__mux4_1
XFILLER_0_111_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7144_ clknet_leaf_64_clk _0735_ VGND VGND VPWR VPWR memory\[3\]\[25\] sky130_fd_sc_hd__dfxtp_1
X_4356_ _1871_ _2021_ VGND VGND VPWR VPWR _2022_ sky130_fd_sc_hd__or2_1
XFILLER_0_1_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7075_ clknet_leaf_62_clk _0666_ VGND VGND VPWR VPWR memory\[4\]\[20\] sky130_fd_sc_hd__dfxtp_1
XTAP_273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4287_ _1954_ _1955_ _1848_ VGND VGND VPWR VPWR _1956_ sky130_fd_sc_hd__mux2_1
XTAP_295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6026_ net881 _3047_ _3051_ _3056_ VGND VGND VPWR VPWR _1064_ sky130_fd_sc_hd__a31o_1
XTAP_1406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_93_clk clknet_4_4_0_clk VGND VGND VPWR VPWR clknet_leaf_93_clk sky130_fd_sc_hd__clkbuf_16
XTAP_1439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6928_ clknet_leaf_17_clk _0519_ VGND VGND VPWR VPWR memory\[10\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_92_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_284 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_64_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_49_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold480 memory\[7\]\[21\] VGND VGND VPWR VPWR net689 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_3_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold491 memory\[2\]\[9\] VGND VGND VPWR VPWR net700 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_99_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_99_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_84_clk clknet_4_7_0_clk VGND VGND VPWR VPWR clknet_leaf_84_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_70_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4210_ _1861_ _1882_ VGND VGND VPWR VPWR _1883_ sky130_fd_sc_hd__and2_1
X_5190_ _2673_ _2655_ VGND VGND VPWR VPWR _2674_ sky130_fd_sc_hd__and2_1
X_4141_ net2 VGND VGND VPWR VPWR _1815_ sky130_fd_sc_hd__buf_4
X_4072_ _1588_ _1748_ VGND VGND VPWR VPWR _1749_ sky130_fd_sc_hd__or2_1
X_7900_ clknet_leaf_88_clk _0434_ VGND VGND VPWR VPWR memory\[17\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_116_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_92_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_75_clk clknet_4_12_0_clk VGND VGND VPWR VPWR clknet_leaf_75_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_116_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7831_ clknet_leaf_13_clk _0365_ VGND VGND VPWR VPWR memory\[9\]\[8\] sky130_fd_sc_hd__dfxtp_1
X_4974_ net1156 _2530_ _2526_ VGND VGND VPWR VPWR _2535_ sky130_fd_sc_hd__and3_1
X_7762_ clknet_leaf_5_clk _0296_ VGND VGND VPWR VPWR memory\[30\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_3925_ memory\[16\]\[21\] memory\[17\]\[21\] memory\[18\]\[21\] memory\[19\]\[21\]
+ _1547_ _1548_ VGND VGND VPWR VPWR _1610_ sky130_fd_sc_hd__mux4_1
X_6713_ net960 _3406_ _3400_ _3409_ VGND VGND VPWR VPWR _0373_ sky130_fd_sc_hd__a31o_1
X_7693_ clknet_leaf_9_clk _0227_ VGND VGND VPWR VPWR memory\[21\]\[30\] sky130_fd_sc_hd__dfxtp_1
X_6644_ _2627_ _3377_ _3379_ net423 VGND VGND VPWR VPWR _0334_ sky130_fd_sc_hd__a22o_1
XFILLER_0_116_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3856_ _1536_ _1544_ VGND VGND VPWR VPWR _1545_ sky130_fd_sc_hd__and2_1
X_3787_ _1154_ VGND VGND VPWR VPWR _1479_ sky130_fd_sc_hd__clkbuf_4
X_6575_ net677 _3346_ _3351_ _3358_ VGND VGND VPWR VPWR _0286_ sky130_fd_sc_hd__a31o_1
XFILLER_0_81_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_14_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5526_ clknet_leaf_76_clk VGND VGND VPWR VPWR _2783_ sky130_fd_sc_hd__buf_1
X_5457_ _2461_ _2767_ _2769_ net332 VGND VGND VPWR VPWR _0782_ sky130_fd_sc_hd__a22o_1
XFILLER_0_100_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4408_ memory\[28\]\[11\] memory\[29\]\[11\] memory\[30\]\[11\] memory\[31\]\[11\]
+ _1965_ _1966_ VGND VGND VPWR VPWR _2071_ sky130_fd_sc_hd__mux4_1
X_5388_ _2474_ _2752_ _2753_ net491 VGND VGND VPWR VPWR _0729_ sky130_fd_sc_hd__a22o_1
XFILLER_0_1_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4339_ _2005_ VGND VGND VPWR VPWR _0061_ sky130_fd_sc_hd__clkbuf_1
X_7127_ clknet_leaf_100_clk _0718_ VGND VGND VPWR VPWR memory\[3\]\[8\] sky130_fd_sc_hd__dfxtp_1
X_7058_ clknet_leaf_10_clk _0649_ VGND VGND VPWR VPWR memory\[4\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_6009_ net833 _3034_ _3035_ _3045_ VGND VGND VPWR VPWR _1058_ sky130_fd_sc_hd__a31o_1
Xclkbuf_leaf_66_clk clknet_4_13_0_clk VGND VGND VPWR VPWR clknet_leaf_66_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_96_346 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_711 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5543__19 clknet_1_0__leaf__2785_ VGND VGND VPWR VPWR net164 sky130_fd_sc_hd__inv_2
XFILLER_0_60_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_57_clk clknet_4_15_0_clk VGND VGND VPWR VPWR clknet_leaf_57_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_62_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XANTENNA_150 _3009_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_1770 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1792 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1781 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_117_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3710_ memory\[0\]\[10\] memory\[1\]\[10\] memory\[2\]\[10\] memory\[3\]\[10\] _1363_
+ _1364_ VGND VGND VPWR VPWR _1406_ sky130_fd_sc_hd__mux4_1
X_4690_ _1871_ _2337_ VGND VGND VPWR VPWR _2338_ sky130_fd_sc_hd__or2_1
XFILLER_0_83_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_703 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_70_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3641_ memory\[0\]\[7\] memory\[1\]\[7\] memory\[2\]\[7\] memory\[3\]\[7\] _1240_
+ _1241_ VGND VGND VPWR VPWR _1340_ sky130_fd_sc_hd__mux4_1
XFILLER_0_70_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3572_ _1267_ _1269_ _1274_ _1207_ _1208_ VGND VGND VPWR VPWR _1275_ sky130_fd_sc_hd__a221o_1
X_6360_ _3145_ VGND VGND VPWR VPWR _3233_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_3_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5311_ _2671_ _2721_ VGND VGND VPWR VPWR _2732_ sky130_fd_sc_hd__and2_1
X_6291_ net385 _3200_ _3196_ _3208_ VGND VGND VPWR VPWR _0152_ sky130_fd_sc_hd__a31o_1
XFILLER_0_87_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5242_ _2440_ _2441_ _2690_ VGND VGND VPWR VPWR _2691_ sky130_fd_sc_hd__and3_4
X_5173_ net600 _2652_ _2653_ _2662_ VGND VGND VPWR VPWR _0605_ sky130_fd_sc_hd__a31o_1
X_4124_ _1797_ VGND VGND VPWR VPWR _1798_ sky130_fd_sc_hd__clkbuf_8
Xinput1 data_addr1[0] VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__clkbuf_4
X_4055_ memory\[28\]\[28\] memory\[29\]\[28\] memory\[30\]\[28\] memory\[31\]\[28\]
+ _1592_ _1593_ VGND VGND VPWR VPWR _1733_ sky130_fd_sc_hd__mux4_1
Xclkbuf_leaf_48_clk clknet_4_14_0_clk VGND VGND VPWR VPWR clknet_leaf_48_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_78_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7814_ clknet_leaf_59_clk _0348_ VGND VGND VPWR VPWR memory\[12\]\[23\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_78_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4957_ _2462_ _2505_ _2524_ VGND VGND VPWR VPWR _0527_ sky130_fd_sc_hd__a21o_1
X_7745_ clknet_leaf_95_clk _0279_ VGND VGND VPWR VPWR memory\[22\]\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_19_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3908_ memory\[28\]\[20\] memory\[29\]\[20\] memory\[30\]\[20\] memory\[31\]\[20\]
+ _1592_ _1593_ VGND VGND VPWR VPWR _1594_ sky130_fd_sc_hd__mux4_1
XFILLER_0_74_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4888_ _2439_ _2494_ _2496_ net337 VGND VGND VPWR VPWR _0485_ sky130_fd_sc_hd__a22o_1
X_7676_ clknet_leaf_94_clk _0210_ VGND VGND VPWR VPWR memory\[21\]\[13\] sky130_fd_sc_hd__dfxtp_1
X_6627_ _2673_ _3373_ _3374_ net273 VGND VGND VPWR VPWR _0322_ sky130_fd_sc_hd__a22o_1
XFILLER_0_116_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3839_ _1528_ VGND VGND VPWR VPWR _0007_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_116_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6558_ _2876_ _3339_ VGND VGND VPWR VPWR _3349_ sky130_fd_sc_hd__and2_1
XFILLER_0_14_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_112_370 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6489_ net501 _3304_ _3307_ _3309_ VGND VGND VPWR VPWR _0249_ sky130_fd_sc_hd__a31o_1
X_5509_ _2646_ _2779_ _2780_ net492 VGND VGND VPWR VPWR _0823_ sky130_fd_sc_hd__a22o_1
XFILLER_0_30_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_39_clk clknet_4_11_0_clk VGND VGND VPWR VPWR clknet_leaf_39_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_69_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1022 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1011 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1000 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1055 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1033 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1044 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1099 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1088 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1077 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1066 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_108_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_108_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_806 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_817 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_828 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_839 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5860_ _2487_ _2918_ _2958_ VGND VGND VPWR VPWR _0964_ sky130_fd_sc_hd__a21o_1
XFILLER_0_48_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4811_ _2451_ _2448_ VGND VGND VPWR VPWR _2452_ sky130_fd_sc_hd__nor2_4
XFILLER_0_88_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_316 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_118_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5791_ _2510_ _2603_ _2736_ VGND VGND VPWR VPWR _2920_ sky130_fd_sc_hd__nand3_4
X_7530_ clknet_leaf_50_clk _1089_ VGND VGND VPWR VPWR memory\[11\]\[27\] sky130_fd_sc_hd__dfxtp_1
X_4742_ _2387_ VGND VGND VPWR VPWR _0052_ sky130_fd_sc_hd__buf_1
XFILLER_0_83_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_563 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_28_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4673_ _2320_ _2321_ _1819_ VGND VGND VPWR VPWR _2322_ sky130_fd_sc_hd__mux2_1
X_7461_ clknet_leaf_62_clk _1020_ VGND VGND VPWR VPWR memory\[1\]\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_43_202 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_98_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6412_ _2881_ _3264_ VGND VGND VPWR VPWR _3265_ sky130_fd_sc_hd__and2_1
X_3624_ memory\[12\]\[6\] memory\[13\]\[6\] memory\[14\]\[6\] memory\[15\]\[6\] _1194_
+ _1195_ VGND VGND VPWR VPWR _1324_ sky130_fd_sc_hd__mux4_1
XFILLER_0_114_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_98_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7392_ clknet_leaf_97_clk _0951_ VGND VGND VPWR VPWR memory\[25\]\[17\] sky130_fd_sc_hd__dfxtp_1
X_3555_ memory\[20\]\[3\] memory\[21\]\[3\] memory\[22\]\[3\] memory\[23\]\[3\] _1157_
+ _1159_ VGND VGND VPWR VPWR _1258_ sky130_fd_sc_hd__mux4_1
X_6343_ _2646_ _3229_ _3230_ net532 VGND VGND VPWR VPWR _0182_ sky130_fd_sc_hd__a22o_1
X_3486_ _1186_ _1191_ VGND VGND VPWR VPWR _1192_ sky130_fd_sc_hd__or2_1
XFILLER_0_12_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6274_ net704 _3187_ _3196_ _3199_ VGND VGND VPWR VPWR _0144_ sky130_fd_sc_hd__a31o_1
X_5225_ _2473_ _2686_ _2687_ net1000 VGND VGND VPWR VPWR _0632_ sky130_fd_sc_hd__a22o_1
XFILLER_0_44_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5156_ net26 VGND VGND VPWR VPWR _2650_ sky130_fd_sc_hd__buf_4
XFILLER_0_98_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5087_ _2529_ VGND VGND VPWR VPWR _2600_ sky130_fd_sc_hd__clkbuf_8
X_4107_ memory\[24\]\[31\] memory\[25\]\[31\] memory\[26\]\[31\] memory\[27\]\[31\]
+ _1251_ _1252_ VGND VGND VPWR VPWR _1782_ sky130_fd_sc_hd__mux4_1
X_4038_ _1591_ _1716_ _1595_ VGND VGND VPWR VPWR _1717_ sky130_fd_sc_hd__o21a_1
XFILLER_0_2_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5989_ _3005_ VGND VGND VPWR VPWR _3034_ sky130_fd_sc_hd__clkbuf_4
XPHY_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_319 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_7728_ clknet_leaf_115_clk _0262_ VGND VGND VPWR VPWR memory\[22\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_74_382 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_62_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XANTENNA_50 _2911_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_83 net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_72 net65 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_61 net1 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7659_ clknet_leaf_26_clk _0193_ VGND VGND VPWR VPWR memory\[19\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_7_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_94 net110 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_100_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_305 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold309 memory\[19\]\[11\] VGND VGND VPWR VPWR net518 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_33_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5010_ _2502_ _2554_ VGND VGND VPWR VPWR _2555_ sky130_fd_sc_hd__nor2_4
XTAP_636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_108_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_108_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6961_ clknet_leaf_112_clk _0552_ VGND VGND VPWR VPWR memory\[6\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_6892_ clknet_leaf_23_clk _0483_ VGND VGND VPWR VPWR memory\[28\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_76_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5912_ net277 _2981_ _2977_ _2989_ VGND VGND VPWR VPWR _1017_ sky130_fd_sc_hd__a31o_1
XFILLER_0_119_705 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5843_ net1143 _2943_ _2947_ VGND VGND VPWR VPWR _2950_ sky130_fd_sc_hd__and3_1
XFILLER_0_75_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_17_714 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5774_ _2909_ VGND VGND VPWR VPWR _2915_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_91_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7513_ clknet_leaf_99_clk _1072_ VGND VGND VPWR VPWR memory\[11\]\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_44_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4725_ memory\[20\]\[28\] memory\[21\]\[28\] memory\[22\]\[28\] memory\[23\]\[28\]
+ _1866_ _1867_ VGND VGND VPWR VPWR _2371_ sky130_fd_sc_hd__mux4_1
XFILLER_0_71_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4656_ memory\[24\]\[24\] memory\[25\]\[24\] memory\[26\]\[24\] memory\[27\]\[24\]
+ _1877_ _1878_ VGND VGND VPWR VPWR _2306_ sky130_fd_sc_hd__mux4_2
X_7444_ clknet_leaf_107_clk _1003_ VGND VGND VPWR VPWR memory\[1\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_32_728 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_102_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4587_ _2235_ _2237_ _2240_ _1978_ _2223_ VGND VGND VPWR VPWR _2241_ sky130_fd_sc_hd__a221o_1
Xhold810 memory\[14\]\[30\] VGND VGND VPWR VPWR net1019 sky130_fd_sc_hd__dlygate4sd3_1
Xhold821 memory\[13\]\[30\] VGND VGND VPWR VPWR net1030 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_71_396 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3607_ memory\[12\]\[5\] memory\[13\]\[5\] memory\[14\]\[5\] memory\[15\]\[5\] _1251_
+ _1252_ VGND VGND VPWR VPWR _1308_ sky130_fd_sc_hd__mux4_1
X_7375_ clknet_leaf_4_clk _0934_ VGND VGND VPWR VPWR memory\[25\]\[0\] sky130_fd_sc_hd__dfxtp_1
Xhold832 memory\[8\]\[28\] VGND VGND VPWR VPWR net1041 sky130_fd_sc_hd__dlygate4sd3_1
Xhold854 memory\[4\]\[25\] VGND VGND VPWR VPWR net1063 sky130_fd_sc_hd__dlygate4sd3_1
X_6326_ _2613_ _3226_ _3228_ net605 VGND VGND VPWR VPWR _0167_ sky130_fd_sc_hd__a22o_1
Xhold843 memory\[1\]\[4\] VGND VGND VPWR VPWR net1052 sky130_fd_sc_hd__dlygate4sd3_1
X_3538_ memory\[0\]\[2\] memory\[1\]\[2\] memory\[2\]\[2\] memory\[3\]\[2\] _1240_
+ _1241_ VGND VGND VPWR VPWR _1242_ sky130_fd_sc_hd__mux4_1
Xhold876 memory\[22\]\[23\] VGND VGND VPWR VPWR net1085 sky130_fd_sc_hd__dlygate4sd3_1
Xhold865 memory\[9\]\[19\] VGND VGND VPWR VPWR net1074 sky130_fd_sc_hd__dlygate4sd3_1
Xhold898 memory\[10\]\[9\] VGND VGND VPWR VPWR net1107 sky130_fd_sc_hd__dlygate4sd3_1
Xhold887 memory\[5\]\[1\] VGND VGND VPWR VPWR net1096 sky130_fd_sc_hd__dlygate4sd3_1
X_6257_ _2845_ _3184_ VGND VGND VPWR VPWR _3190_ sky130_fd_sc_hd__and2_1
X_3469_ _1169_ _1174_ VGND VGND VPWR VPWR _1175_ sky130_fd_sc_hd__or2_1
X_6188_ _2851_ _3140_ VGND VGND VPWR VPWR _3150_ sky130_fd_sc_hd__and2_1
X_5208_ _2456_ _2683_ _2685_ net434 VGND VGND VPWR VPWR _0617_ sky130_fd_sc_hd__a22o_1
XFILLER_0_99_706 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5139_ _2638_ _2632_ VGND VGND VPWR VPWR _2639_ sky130_fd_sc_hd__and2_1
XFILLER_0_67_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_511 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_47_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_330 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_117_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_514 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_105_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_57_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4510_ _2113_ _2167_ VGND VGND VPWR VPWR _2168_ sky130_fd_sc_hd__or2_1
XFILLER_0_41_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5490_ _2607_ _2776_ _2778_ net314 VGND VGND VPWR VPWR _0806_ sky130_fd_sc_hd__a22o_1
Xhold117 memory\[28\]\[26\] VGND VGND VPWR VPWR net326 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_102_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold106 memory\[1\]\[8\] VGND VGND VPWR VPWR net315 sky130_fd_sc_hd__dlygate4sd3_1
X_4441_ _2101_ _2102_ VGND VGND VPWR VPWR _2103_ sky130_fd_sc_hd__or2_1
Xhold128 memory\[15\]\[0\] VGND VGND VPWR VPWR net337 sky130_fd_sc_hd__dlygate4sd3_1
Xhold139 memory\[21\]\[7\] VGND VGND VPWR VPWR net348 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_121 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_7160_ clknet_leaf_103_clk _0751_ VGND VGND VPWR VPWR memory\[2\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_41_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6111_ net1050 _3104_ _3095_ _3105_ VGND VGND VPWR VPWR _1100_ sky130_fd_sc_hd__a31o_1
X_4372_ _1820_ _2036_ _1824_ VGND VGND VPWR VPWR _2037_ sky130_fd_sc_hd__o21a_1
XTAP_433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7091_ clknet_leaf_4_clk _0682_ VGND VGND VPWR VPWR memory\[29\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_6042_ _3050_ VGND VGND VPWR VPWR _3065_ sky130_fd_sc_hd__buf_4
XTAP_444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6944_ clknet_leaf_73_clk _0535_ VGND VGND VPWR VPWR memory\[10\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_88_282 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6875_ clknet_leaf_87_clk _0466_ VGND VGND VPWR VPWR memory\[28\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_76_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5826_ memory\[25\]\[15\] _2930_ _2934_ VGND VGND VPWR VPWR _2940_ sky130_fd_sc_hd__and3_1
XFILLER_0_106_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5757_ _2619_ _2910_ _2912_ net964 VGND VGND VPWR VPWR _0907_ sky130_fd_sc_hd__a22o_1
X_4708_ memory\[16\]\[27\] memory\[17\]\[27\] memory\[18\]\[27\] memory\[19\]\[27\]
+ _1800_ _1802_ VGND VGND VPWR VPWR _2355_ sky130_fd_sc_hd__mux4_1
XFILLER_0_72_672 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7427_ clknet_leaf_66_clk net125 VGND VGND VPWR VPWR memory\[0\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_71_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5688_ _2730_ VGND VGND VPWR VPWR _2867_ sky130_fd_sc_hd__clkbuf_4
X_4639_ memory\[20\]\[23\] memory\[21\]\[23\] memory\[22\]\[23\] memory\[23\]\[23\]
+ _1831_ _1833_ VGND VGND VPWR VPWR _2290_ sky130_fd_sc_hd__mux4_1
XFILLER_0_32_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold662 memory\[17\]\[26\] VGND VGND VPWR VPWR net871 sky130_fd_sc_hd__dlygate4sd3_1
Xhold640 memory\[23\]\[15\] VGND VGND VPWR VPWR net849 sky130_fd_sc_hd__dlygate4sd3_1
X_7358_ clknet_leaf_88_clk _0917_ VGND VGND VPWR VPWR memory\[18\]\[15\] sky130_fd_sc_hd__dfxtp_1
Xhold651 memory\[23\]\[11\] VGND VGND VPWR VPWR net860 sky130_fd_sc_hd__dlygate4sd3_1
X_6309_ _2897_ _3210_ VGND VGND VPWR VPWR _3219_ sky130_fd_sc_hd__and2_1
Xhold684 memory\[19\]\[16\] VGND VGND VPWR VPWR net893 sky130_fd_sc_hd__dlygate4sd3_1
Xhold695 memory\[16\]\[1\] VGND VGND VPWR VPWR net904 sky130_fd_sc_hd__dlygate4sd3_1
Xhold673 memory\[24\]\[3\] VGND VGND VPWR VPWR net882 sky130_fd_sc_hd__dlygate4sd3_1
X_7289_ clknet_leaf_76_clk _0848_ VGND VGND VPWR VPWR memory\[8\]\[10\] sky130_fd_sc_hd__dfxtp_1
X_6842__50 clknet_1_0__leaf__3445_ VGND VGND VPWR VPWR net195 sky130_fd_sc_hd__inv_2
XFILLER_0_99_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_79_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_95_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_94_230 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_55_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_4_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_78_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4990_ _2479_ _2539_ _2544_ VGND VGND VPWR VPWR _0540_ sky130_fd_sc_hd__a21o_1
X_3941_ _1625_ VGND VGND VPWR VPWR _0013_ sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_58_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6660_ _2657_ _3382_ _3383_ net797 VGND VGND VPWR VPWR _0346_ sky130_fd_sc_hd__a22o_1
XFILLER_0_105_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3872_ memory\[12\]\[18\] memory\[13\]\[18\] memory\[14\]\[18\] memory\[15\]\[18\]
+ _1188_ _1190_ VGND VGND VPWR VPWR _1560_ sky130_fd_sc_hd__mux4_1
XFILLER_0_14_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_116_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5611_ _2788_ VGND VGND VPWR VPWR _2816_ sky130_fd_sc_hd__clkbuf_4
X_6591_ _3367_ VGND VGND VPWR VPWR _3368_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_45_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_121_31 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_26_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_121_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5473_ _2475_ _2772_ _2773_ net701 VGND VGND VPWR VPWR _0794_ sky130_fd_sc_hd__a22o_1
X_7212_ clknet_leaf_37_clk _0803_ VGND VGND VPWR VPWR memory\[14\]\[29\] sky130_fd_sc_hd__dfxtp_1
X_4424_ _1797_ VGND VGND VPWR VPWR _2086_ sky130_fd_sc_hd__buf_4
X_7143_ clknet_leaf_63_clk _0734_ VGND VGND VPWR VPWR memory\[3\]\[24\] sky130_fd_sc_hd__dfxtp_1
X_4355_ memory\[8\]\[8\] memory\[9\]\[8\] memory\[10\]\[8\] memory\[11\]\[8\] _1913_
+ _1914_ VGND VGND VPWR VPWR _2021_ sky130_fd_sc_hd__mux4_1
XFILLER_0_1_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_7074_ clknet_leaf_80_clk _0665_ VGND VGND VPWR VPWR memory\[4\]\[19\] sky130_fd_sc_hd__dfxtp_1
XTAP_252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4286_ memory\[0\]\[5\] memory\[1\]\[5\] memory\[2\]\[5\] memory\[3\]\[5\] _1845_
+ _1846_ VGND VGND VPWR VPWR _1955_ sky130_fd_sc_hd__mux4_1
XTAP_285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6025_ _2840_ _3053_ VGND VGND VPWR VPWR _3056_ sky130_fd_sc_hd__and2_1
XTAP_1429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6927_ clknet_leaf_17_clk _0518_ VGND VGND VPWR VPWR memory\[10\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_37_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_49_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_458 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5809_ _2529_ VGND VGND VPWR VPWR _2930_ sky130_fd_sc_hd__clkbuf_4
X_6789_ _3437_ VGND VGND VPWR VPWR _3438_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_102_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold470 memory\[15\]\[7\] VGND VGND VPWR VPWR net679 sky130_fd_sc_hd__dlygate4sd3_1
Xhold481 memory\[21\]\[16\] VGND VGND VPWR VPWR net690 sky130_fd_sc_hd__dlygate4sd3_1
Xhold492 memory\[14\]\[20\] VGND VGND VPWR VPWR net701 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_99_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_55_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_121_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4140_ _1813_ VGND VGND VPWR VPWR _1814_ sky130_fd_sc_hd__buf_6
X_4071_ memory\[24\]\[29\] memory\[25\]\[29\] memory\[26\]\[29\] memory\[27\]\[29\]
+ _1251_ _1252_ VGND VGND VPWR VPWR _1748_ sky130_fd_sc_hd__mux4_1
X_7830_ clknet_leaf_20_clk _0364_ VGND VGND VPWR VPWR memory\[9\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_4973_ _2470_ _2525_ _2534_ VGND VGND VPWR VPWR _0533_ sky130_fd_sc_hd__a21o_1
XFILLER_0_58_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7761_ clknet_leaf_4_clk _0295_ VGND VGND VPWR VPWR memory\[30\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_3924_ memory\[20\]\[21\] memory\[21\]\[21\] memory\[22\]\[21\] memory\[23\]\[21\]
+ _1509_ _1510_ VGND VGND VPWR VPWR _1609_ sky130_fd_sc_hd__mux4_1
X_7692_ clknet_leaf_24_clk _0226_ VGND VGND VPWR VPWR memory\[21\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_19_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6712_ net23 _3401_ VGND VGND VPWR VPWR _3409_ sky130_fd_sc_hd__and2_1
X_6643_ _2625_ _3377_ _3379_ net729 VGND VGND VPWR VPWR _0333_ sky130_fd_sc_hd__a22o_1
XFILLER_0_18_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3855_ _1479_ _1539_ _1541_ _1543_ _1412_ VGND VGND VPWR VPWR _1544_ sky130_fd_sc_hd__a221o_1
X_6574_ _2893_ _3352_ VGND VGND VPWR VPWR _3358_ sky130_fd_sc_hd__and2_1
X_3786_ _1390_ _1473_ _1475_ _1477_ _1403_ VGND VGND VPWR VPWR _1478_ sky130_fd_sc_hd__a221o_1
X_5525_ _2678_ _2775_ _2777_ net215 VGND VGND VPWR VPWR _0837_ sky130_fd_sc_hd__a22o_1
XFILLER_0_112_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5456_ _2460_ _2767_ _2769_ net933 VGND VGND VPWR VPWR _0781_ sky130_fd_sc_hd__a22o_1
X_4407_ _1959_ _2069_ VGND VGND VPWR VPWR _2070_ sky130_fd_sc_hd__or2_1
XFILLER_0_112_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5387_ _2473_ _2752_ _2753_ net784 VGND VGND VPWR VPWR _0728_ sky130_fd_sc_hd__a22o_1
XFILLER_0_1_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4338_ _1996_ _2004_ VGND VGND VPWR VPWR _2005_ sky130_fd_sc_hd__and2_1
X_7126_ clknet_leaf_104_clk _0717_ VGND VGND VPWR VPWR memory\[3\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_4269_ _1799_ VGND VGND VPWR VPWR _1938_ sky130_fd_sc_hd__buf_6
X_7057_ clknet_leaf_105_clk _0648_ VGND VGND VPWR VPWR memory\[4\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_6008_ _2899_ _3036_ VGND VGND VPWR VPWR _3045_ sky130_fd_sc_hd__and2_1
XTAP_1204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_115_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_140 net52 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_151 _3227_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_1760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1793 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1782 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1771 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_266 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3640_ memory\[4\]\[7\] memory\[5\]\[7\] memory\[6\]\[7\] memory\[7\]\[7\] _1237_
+ _1238_ VGND VGND VPWR VPWR _1339_ sky130_fd_sc_hd__mux4_1
XFILLER_0_102_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3571_ _1270_ _1273_ _1205_ VGND VGND VPWR VPWR _1274_ sky130_fd_sc_hd__mux2_1
X_5310_ _2730_ VGND VGND VPWR VPWR _2731_ sky130_fd_sc_hd__buf_4
XFILLER_0_23_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6290_ _2878_ _3197_ VGND VGND VPWR VPWR _3208_ sky130_fd_sc_hd__and2_1
XFILLER_0_11_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5241_ _2442_ VGND VGND VPWR VPWR _2690_ sky130_fd_sc_hd__buf_2
X_5172_ _2661_ _2655_ VGND VGND VPWR VPWR _2662_ sky130_fd_sc_hd__and2_1
X_4123_ _1796_ VGND VGND VPWR VPWR _1797_ sky130_fd_sc_hd__clkinv_4
X_4054_ _1588_ _1731_ VGND VGND VPWR VPWR _1732_ sky130_fd_sc_hd__or2_1
Xinput2 data_addr1[1] VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_78_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7813_ clknet_leaf_58_clk _0347_ VGND VGND VPWR VPWR memory\[12\]\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_59_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7744_ clknet_leaf_108_clk _0278_ VGND VGND VPWR VPWR memory\[22\]\[17\] sky130_fd_sc_hd__dfxtp_1
X_4956_ net1107 _2516_ _2513_ VGND VGND VPWR VPWR _2524_ sky130_fd_sc_hd__and3_1
XFILLER_0_59_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3907_ _1172_ VGND VGND VPWR VPWR _1593_ sky130_fd_sc_hd__clkbuf_4
X_4887_ _2495_ VGND VGND VPWR VPWR _2496_ sky130_fd_sc_hd__buf_4
XFILLER_0_62_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7675_ clknet_leaf_94_clk _0209_ VGND VGND VPWR VPWR memory\[21\]\[12\] sky130_fd_sc_hd__dfxtp_1
X_6626_ _2671_ _3373_ _3374_ net666 VGND VGND VPWR VPWR _0321_ sky130_fd_sc_hd__a22o_1
XFILLER_0_61_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3838_ _1518_ _1527_ VGND VGND VPWR VPWR _1528_ sky130_fd_sc_hd__and2_1
XFILLER_0_116_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_116_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_104_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6557_ net724 _3346_ _3338_ _3348_ VGND VGND VPWR VPWR _0278_ sky130_fd_sc_hd__a31o_1
XFILLER_0_15_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5508_ _2644_ _2779_ _2780_ net522 VGND VGND VPWR VPWR _0822_ sky130_fd_sc_hd__a22o_1
XFILLER_0_42_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3769_ memory\[0\]\[13\] memory\[1\]\[13\] memory\[2\]\[13\] memory\[3\]\[13\] _1363_
+ _1364_ VGND VGND VPWR VPWR _1462_ sky130_fd_sc_hd__mux4_1
X_6488_ _2881_ _3308_ VGND VGND VPWR VPWR _3309_ sky130_fd_sc_hd__and2_1
XFILLER_0_112_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5439_ _2484_ _2763_ _2764_ net905 VGND VGND VPWR VPWR _0769_ sky130_fd_sc_hd__a22o_1
XFILLER_0_100_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_100_511 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_100_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7109_ clknet_leaf_37_clk _0700_ VGND VGND VPWR VPWR memory\[29\]\[22\] sky130_fd_sc_hd__dfxtp_1
XTAP_1012 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1001 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1056 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1034 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1045 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1023 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_77_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1089 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1078 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1067 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_122_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_103_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_539 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_807 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_818 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_829 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4810_ _2450_ VGND VGND VPWR VPWR _2451_ sky130_fd_sc_hd__buf_8
XFILLER_0_75_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_75_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_628 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5790_ _2918_ VGND VGND VPWR VPWR _2919_ sky130_fd_sc_hd__clkbuf_4
XTAP_1590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4741_ _2378_ _2386_ VGND VGND VPWR VPWR _2387_ sky130_fd_sc_hd__and2_1
XFILLER_0_56_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4672_ memory\[16\]\[25\] memory\[17\]\[25\] memory\[18\]\[25\] memory\[19\]\[25\]
+ _1800_ _1802_ VGND VGND VPWR VPWR _2321_ sky130_fd_sc_hd__mux4_1
X_7460_ clknet_leaf_62_clk _1019_ VGND VGND VPWR VPWR memory\[1\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_43_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6411_ _3237_ VGND VGND VPWR VPWR _3264_ sky130_fd_sc_hd__buf_2
XFILLER_0_71_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3623_ _1186_ _1322_ VGND VGND VPWR VPWR _1323_ sky130_fd_sc_hd__or2_1
XFILLER_0_31_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_114_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7391_ clknet_leaf_90_clk _0950_ VGND VGND VPWR VPWR memory\[25\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_12_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_11_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6342_ _2644_ _3229_ _3230_ net893 VGND VGND VPWR VPWR _0181_ sky130_fd_sc_hd__a22o_1
X_3554_ _1257_ VGND VGND VPWR VPWR _0022_ sky130_fd_sc_hd__clkbuf_1
X_3485_ memory\[8\]\[0\] memory\[9\]\[0\] memory\[10\]\[0\] memory\[11\]\[0\] _1188_
+ _1190_ VGND VGND VPWR VPWR _1191_ sky130_fd_sc_hd__mux4_1
X_6273_ _2861_ _3197_ VGND VGND VPWR VPWR _3199_ sky130_fd_sc_hd__and2_1
X_5224_ _2472_ _2686_ _2687_ net424 VGND VGND VPWR VPWR _0631_ sky130_fd_sc_hd__a22o_1
X_5155_ net488 _2629_ _2630_ _2649_ VGND VGND VPWR VPWR _0600_ sky130_fd_sc_hd__a31o_1
X_5086_ _2488_ _2555_ _2599_ VGND VGND VPWR VPWR _0581_ sky130_fd_sc_hd__a21o_1
X_4106_ _1779_ _1780_ _1176_ VGND VGND VPWR VPWR _1781_ sky130_fd_sc_hd__mux2_1
X_4037_ memory\[28\]\[27\] memory\[29\]\[27\] memory\[30\]\[27\] memory\[31\]\[27\]
+ _1592_ _1593_ VGND VGND VPWR VPWR _1716_ sky130_fd_sc_hd__mux4_1
XFILLER_0_79_623 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_78_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_109_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5988_ net862 _3021_ _3022_ _3033_ VGND VGND VPWR VPWR _1049_ sky130_fd_sc_hd__a31o_1
X_4939_ net1130 _2509_ _2513_ VGND VGND VPWR VPWR _2515_ sky130_fd_sc_hd__and3_1
X_7727_ clknet_leaf_115_clk _0261_ VGND VGND VPWR VPWR memory\[22\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_7658_ clknet_leaf_32_clk _0192_ VGND VGND VPWR VPWR memory\[19\]\[27\] sky130_fd_sc_hd__dfxtp_1
XANTENNA_40 _2694_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_394 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_74_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_84 net93 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_73 net66 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_62 net49 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_51 _2911_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6609_ _2638_ _3371_ _3372_ net588 VGND VGND VPWR VPWR _0306_ sky130_fd_sc_hd__a22o_1
XFILLER_0_50_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7589_ clknet_leaf_26_clk _1148_ VGND VGND VPWR VPWR memory\[23\]\[22\] sky130_fd_sc_hd__dfxtp_1
XANTENNA_95 _1183_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_104_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6849__56 clknet_1_1__leaf__3446_ VGND VGND VPWR VPWR net201 sky130_fd_sc_hd__inv_2
XFILLER_0_69_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_25_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_375 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_111_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6960_ clknet_leaf_104_clk _0551_ VGND VGND VPWR VPWR memory\[6\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_5911_ _2878_ _2978_ VGND VGND VPWR VPWR _2989_ sky130_fd_sc_hd__and2_1
X_6891_ clknet_leaf_35_clk _0482_ VGND VGND VPWR VPWR memory\[28\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_119_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5842_ _2478_ _2946_ _2949_ VGND VGND VPWR VPWR _0955_ sky130_fd_sc_hd__a21o_1
XFILLER_0_91_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5773_ _2650_ _2913_ _2914_ net476 VGND VGND VPWR VPWR _0921_ sky130_fd_sc_hd__a22o_1
X_4724_ _2370_ VGND VGND VPWR VPWR _0051_ sky130_fd_sc_hd__clkbuf_1
X_7512_ clknet_leaf_44_clk _1071_ VGND VGND VPWR VPWR memory\[11\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_17_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4655_ _2303_ _2304_ _1819_ VGND VGND VPWR VPWR _2305_ sky130_fd_sc_hd__mux2_1
XFILLER_0_71_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7443_ clknet_leaf_103_clk _1002_ VGND VGND VPWR VPWR memory\[1\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_44_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4586_ _2238_ _2239_ _1848_ VGND VGND VPWR VPWR _2240_ sky130_fd_sc_hd__mux2_1
X_7374_ clknet_leaf_16_clk _0933_ VGND VGND VPWR VPWR memory\[18\]\[31\] sky130_fd_sc_hd__dfxtp_1
X_3606_ _1245_ _1306_ VGND VGND VPWR VPWR _1307_ sky130_fd_sc_hd__or2_1
Xhold811 memory\[16\]\[11\] VGND VGND VPWR VPWR net1020 sky130_fd_sc_hd__dlygate4sd3_1
Xhold800 memory\[23\]\[10\] VGND VGND VPWR VPWR net1009 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_24_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold855 memory\[27\]\[22\] VGND VGND VPWR VPWR net1064 sky130_fd_sc_hd__dlygate4sd3_1
Xhold833 memory\[19\]\[22\] VGND VGND VPWR VPWR net1042 sky130_fd_sc_hd__dlygate4sd3_1
Xhold844 memory\[13\]\[9\] VGND VGND VPWR VPWR net1053 sky130_fd_sc_hd__dlygate4sd3_1
Xhold822 memory\[8\]\[4\] VGND VGND VPWR VPWR net1031 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_3_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6325_ _2611_ _3226_ _3228_ net816 VGND VGND VPWR VPWR _0166_ sky130_fd_sc_hd__a22o_1
X_3537_ _1158_ VGND VGND VPWR VPWR _1241_ sky130_fd_sc_hd__buf_4
Xhold888 memory\[4\]\[24\] VGND VGND VPWR VPWR net1097 sky130_fd_sc_hd__dlygate4sd3_1
Xhold877 memory\[16\]\[14\] VGND VGND VPWR VPWR net1086 sky130_fd_sc_hd__dlygate4sd3_1
Xhold866 memory\[21\]\[30\] VGND VGND VPWR VPWR net1075 sky130_fd_sc_hd__dlygate4sd3_1
Xhold899 memory\[25\]\[30\] VGND VGND VPWR VPWR net1108 sky130_fd_sc_hd__dlygate4sd3_1
X_6256_ net597 _3187_ _3182_ _3189_ VGND VGND VPWR VPWR _0136_ sky130_fd_sc_hd__a31o_1
X_3468_ memory\[24\]\[0\] memory\[25\]\[0\] memory\[26\]\[0\] memory\[27\]\[0\] _1171_
+ _1173_ VGND VGND VPWR VPWR _1174_ sky130_fd_sc_hd__mux4_1
X_6187_ net744 _3146_ _3138_ _3149_ VGND VGND VPWR VPWR _1132_ sky130_fd_sc_hd__a31o_1
X_5207_ _2455_ _2683_ _2685_ net732 VGND VGND VPWR VPWR _0616_ sky130_fd_sc_hd__a22o_1
XFILLER_0_99_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5138_ net20 VGND VGND VPWR VPWR _2638_ sky130_fd_sc_hd__buf_4
X_5069_ _2480_ _2584_ _2590_ VGND VGND VPWR VPWR _0573_ sky130_fd_sc_hd__a21o_1
XFILLER_0_79_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_105_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_491 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_50_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_105_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_456 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_70_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_108_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold107 memory\[21\]\[6\] VGND VGND VPWR VPWR net316 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_41_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4440_ memory\[8\]\[12\] memory\[9\]\[12\] memory\[10\]\[12\] memory\[11\]\[12\]
+ _1913_ _1914_ VGND VGND VPWR VPWR _2102_ sky130_fd_sc_hd__mux4_1
Xhold129 memory\[15\]\[15\] VGND VGND VPWR VPWR net338 sky130_fd_sc_hd__dlygate4sd3_1
Xhold118 memory\[11\]\[13\] VGND VGND VPWR VPWR net327 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_100 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_111_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6110_ _2849_ _3097_ VGND VGND VPWR VPWR _3105_ sky130_fd_sc_hd__and2_1
XFILLER_0_0_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4371_ memory\[28\]\[9\] memory\[29\]\[9\] memory\[30\]\[9\] memory\[31\]\[9\] _1821_
+ _1822_ VGND VGND VPWR VPWR _2036_ sky130_fd_sc_hd__mux4_1
XFILLER_0_95_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6828__37 clknet_1_0__leaf__2787_ VGND VGND VPWR VPWR net182 sky130_fd_sc_hd__inv_2
XTAP_423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_155 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_7090_ clknet_leaf_5_clk _0681_ VGND VGND VPWR VPWR memory\[29\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_6041_ net515 _3062_ _3051_ _3064_ VGND VGND VPWR VPWR _1071_ sky130_fd_sc_hd__a31o_1
XTAP_434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_88_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6943_ clknet_leaf_69_clk _0534_ VGND VGND VPWR VPWR memory\[10\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_88_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6874_ clknet_leaf_84_clk _0465_ VGND VGND VPWR VPWR memory\[28\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_49_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5825_ _2469_ _2933_ _2939_ VGND VGND VPWR VPWR _0948_ sky130_fd_sc_hd__a21o_1
XFILLER_0_36_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_107_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5756_ _2617_ _2910_ _2912_ net789 VGND VGND VPWR VPWR _0906_ sky130_fd_sc_hd__a22o_1
X_4707_ memory\[20\]\[27\] memory\[21\]\[27\] memory\[22\]\[27\] memory\[23\]\[27\]
+ _1866_ _1867_ VGND VGND VPWR VPWR _2354_ sky130_fd_sc_hd__mux4_1
XFILLER_0_71_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5687_ net847 _2844_ _2857_ _2866_ VGND VGND VPWR VPWR _0883_ sky130_fd_sc_hd__a31o_1
X_4638_ _1836_ _2288_ _1840_ VGND VGND VPWR VPWR _2289_ sky130_fd_sc_hd__o21a_1
X_7426_ clknet_leaf_67_clk net126 VGND VGND VPWR VPWR memory\[0\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_32_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold630 memory\[5\]\[10\] VGND VGND VPWR VPWR net839 sky130_fd_sc_hd__dlygate4sd3_1
X_7357_ clknet_leaf_93_clk _0916_ VGND VGND VPWR VPWR memory\[18\]\[14\] sky130_fd_sc_hd__dfxtp_1
Xhold663 memory\[23\]\[12\] VGND VGND VPWR VPWR net872 sky130_fd_sc_hd__dlygate4sd3_1
Xhold652 memory\[29\]\[12\] VGND VGND VPWR VPWR net861 sky130_fd_sc_hd__dlygate4sd3_1
Xhold641 memory\[30\]\[5\] VGND VGND VPWR VPWR net850 sky130_fd_sc_hd__dlygate4sd3_1
X_4569_ _2086_ _2218_ _2220_ _2222_ _2223_ VGND VGND VPWR VPWR _2224_ sky130_fd_sc_hd__a221o_1
X_6308_ net682 _3213_ _3209_ _3218_ VGND VGND VPWR VPWR _0159_ sky130_fd_sc_hd__a31o_1
Xhold696 memory\[2\]\[27\] VGND VGND VPWR VPWR net905 sky130_fd_sc_hd__dlygate4sd3_1
Xhold674 memory\[22\]\[24\] VGND VGND VPWR VPWR net883 sky130_fd_sc_hd__dlygate4sd3_1
X_7288_ clknet_leaf_43_clk _0847_ VGND VGND VPWR VPWR memory\[8\]\[9\] sky130_fd_sc_hd__dfxtp_1
Xhold685 memory\[9\]\[4\] VGND VGND VPWR VPWR net894 sky130_fd_sc_hd__dlygate4sd3_1
X_6239_ net965 _3172_ _3166_ _3178_ VGND VGND VPWR VPWR _0130_ sky130_fd_sc_hd__a31o_1
XTAP_990 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_120_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_77_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3940_ _1616_ _1624_ VGND VGND VPWR VPWR _1625_ sky130_fd_sc_hd__and2_1
XFILLER_0_85_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3871_ _1186_ _1558_ VGND VGND VPWR VPWR _1559_ sky130_fd_sc_hd__or2_1
X_6590_ _3366_ VGND VGND VPWR VPWR _3367_ sky130_fd_sc_hd__buf_4
X_5610_ net1084 _2811_ _2803_ _2815_ VGND VGND VPWR VPWR _0857_ sky130_fd_sc_hd__a31o_1
XFILLER_0_26_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_121_43 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_112_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_54_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7211_ clknet_leaf_52_clk _0802_ VGND VGND VPWR VPWR memory\[14\]\[28\] sky130_fd_sc_hd__dfxtp_1
X_5472_ _2768_ VGND VGND VPWR VPWR _2773_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_30_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_431 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4423_ _2085_ VGND VGND VPWR VPWR _0034_ sky130_fd_sc_hd__clkbuf_1
X_7142_ clknet_leaf_57_clk _0733_ VGND VGND VPWR VPWR memory\[3\]\[23\] sky130_fd_sc_hd__dfxtp_1
X_4354_ _2016_ _2019_ _1869_ VGND VGND VPWR VPWR _2020_ sky130_fd_sc_hd__mux2_1
X_7073_ clknet_leaf_81_clk _0664_ VGND VGND VPWR VPWR memory\[4\]\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_1_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6024_ net415 _3047_ _3051_ _3055_ VGND VGND VPWR VPWR _1063_ sky130_fd_sc_hd__a31o_1
XTAP_275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4285_ memory\[4\]\[5\] memory\[5\]\[5\] memory\[6\]\[5\] memory\[7\]\[5\] _1842_
+ _1843_ VGND VGND VPWR VPWR _1954_ sky130_fd_sc_hd__mux4_1
XTAP_286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6926_ clknet_leaf_17_clk _0517_ VGND VGND VPWR VPWR set\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_77_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_119_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6788_ _3436_ VGND VGND VPWR VPWR _3437_ sky130_fd_sc_hd__buf_4
XFILLER_0_17_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5808_ _2460_ _2919_ _2929_ VGND VGND VPWR VPWR _0941_ sky130_fd_sc_hd__a21o_1
X_5739_ net760 _2890_ _2880_ _2902_ VGND VGND VPWR VPWR _0899_ sky130_fd_sc_hd__a31o_1
XFILLER_0_44_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7409_ clknet_leaf_10_clk net143 VGND VGND VPWR VPWR memory\[0\]\[2\] sky130_fd_sc_hd__dfxtp_1
Xhold471 memory\[8\]\[17\] VGND VGND VPWR VPWR net680 sky130_fd_sc_hd__dlygate4sd3_1
Xhold460 memory\[19\]\[12\] VGND VGND VPWR VPWR net669 sky130_fd_sc_hd__dlygate4sd3_1
Xhold493 memory\[11\]\[22\] VGND VGND VPWR VPWR net702 sky130_fd_sc_hd__dlygate4sd3_1
Xhold482 memory\[31\]\[18\] VGND VGND VPWR VPWR net691 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_99_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_481 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_35_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_50_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4070_ _1745_ _1746_ _1176_ VGND VGND VPWR VPWR _1747_ sky130_fd_sc_hd__mux2_1
X_4972_ memory\[10\]\[15\] _2530_ _2526_ VGND VGND VPWR VPWR _2534_ sky130_fd_sc_hd__and3_1
X_7760_ clknet_leaf_6_clk _0294_ VGND VGND VPWR VPWR memory\[30\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_7691_ clknet_leaf_23_clk _0225_ VGND VGND VPWR VPWR memory\[21\]\[28\] sky130_fd_sc_hd__dfxtp_1
X_3923_ _1608_ VGND VGND VPWR VPWR _0012_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_58_275 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_58_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6711_ net475 _3406_ _3400_ _3408_ VGND VGND VPWR VPWR _0372_ sky130_fd_sc_hd__a31o_1
X_3854_ _1486_ _1542_ _1488_ VGND VGND VPWR VPWR _1543_ sky130_fd_sc_hd__o21a_1
X_6642_ _2623_ _3377_ _3379_ net631 VGND VGND VPWR VPWR _0332_ sky130_fd_sc_hd__a22o_1
X_6573_ net883 _3346_ _3351_ _3357_ VGND VGND VPWR VPWR _0285_ sky130_fd_sc_hd__a31o_1
X_3785_ _1397_ _1476_ _1401_ VGND VGND VPWR VPWR _1477_ sky130_fd_sc_hd__o21a_1
X_5524_ _2676_ _2775_ _2777_ net900 VGND VGND VPWR VPWR _0836_ sky130_fd_sc_hd__a22o_1
XFILLER_0_41_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_112_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5455_ _2459_ _2767_ _2769_ net917 VGND VGND VPWR VPWR _0780_ sky130_fd_sc_hd__a22o_1
XFILLER_0_42_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_67_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4406_ memory\[24\]\[11\] memory\[25\]\[11\] memory\[26\]\[11\] memory\[27\]\[11\]
+ _1872_ _1873_ VGND VGND VPWR VPWR _2069_ sky130_fd_sc_hd__mux4_1
X_5386_ _2472_ _2752_ _2753_ net672 VGND VGND VPWR VPWR _0727_ sky130_fd_sc_hd__a22o_1
XFILLER_0_10_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7125_ clknet_leaf_103_clk _0716_ VGND VGND VPWR VPWR memory\[3\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_4337_ _1998_ _2000_ _2003_ _1850_ _1851_ VGND VGND VPWR VPWR _2004_ sky130_fd_sc_hd__a221o_1
X_4268_ _1937_ VGND VGND VPWR VPWR _0058_ sky130_fd_sc_hd__clkbuf_1
X_7056_ clknet_leaf_10_clk _0647_ VGND VGND VPWR VPWR memory\[4\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_6007_ net595 _3034_ _3035_ _3044_ VGND VGND VPWR VPWR _1057_ sky130_fd_sc_hd__a31o_1
X_4199_ _1830_ VGND VGND VPWR VPWR _1872_ sky130_fd_sc_hd__clkbuf_16
XTAP_1205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_1238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6909_ clknet_leaf_69_clk _0500_ VGND VGND VPWR VPWR memory\[15\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_64_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7889_ clknet_leaf_116_clk _0423_ VGND VGND VPWR VPWR memory\[17\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_49_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_119_152 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_37_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_92_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_122_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold290 memory\[20\]\[13\] VGND VGND VPWR VPWR net499 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_141 net72 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_152 _3227_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_130 _2918_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_1761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1794 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1783 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1772 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_102_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3570_ memory\[0\]\[3\] memory\[1\]\[3\] memory\[2\]\[3\] memory\[3\]\[3\] _1271_
+ _1272_ VGND VGND VPWR VPWR _1273_ sky130_fd_sc_hd__mux4_1
XFILLER_0_3_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5240_ _2488_ _2682_ _2684_ net998 VGND VGND VPWR VPWR _0645_ sky130_fd_sc_hd__a22o_1
XFILLER_0_11_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5171_ net31 VGND VGND VPWR VPWR _2661_ sky130_fd_sc_hd__buf_4
X_4122_ net4 VGND VGND VPWR VPWR _1796_ sky130_fd_sc_hd__buf_4
X_4053_ memory\[24\]\[28\] memory\[25\]\[28\] memory\[26\]\[28\] memory\[27\]\[28\]
+ _1251_ _1252_ VGND VGND VPWR VPWR _1731_ sky130_fd_sc_hd__mux4_1
Xinput3 data_addr1[2] VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__clkbuf_2
X_7812_ clknet_leaf_58_clk _0346_ VGND VGND VPWR VPWR memory\[12\]\[21\] sky130_fd_sc_hd__dfxtp_1
X_4955_ _2461_ _2505_ _2523_ VGND VGND VPWR VPWR _0526_ sky130_fd_sc_hd__a21o_1
X_7743_ clknet_leaf_109_clk _0277_ VGND VGND VPWR VPWR memory\[22\]\[16\] sky130_fd_sc_hd__dfxtp_1
X_3906_ _1170_ VGND VGND VPWR VPWR _1592_ sky130_fd_sc_hd__buf_4
XFILLER_0_19_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4886_ _2451_ _2493_ VGND VGND VPWR VPWR _2495_ sky130_fd_sc_hd__nor2_4
XFILLER_0_74_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7674_ clknet_leaf_109_clk _0208_ VGND VGND VPWR VPWR memory\[21\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_117_656 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6625_ _2669_ _3373_ _3374_ net372 VGND VGND VPWR VPWR _0320_ sky130_fd_sc_hd__a22o_1
X_3837_ _1479_ _1522_ _1524_ _1526_ _1412_ VGND VGND VPWR VPWR _1527_ sky130_fd_sc_hd__a221o_1
XFILLER_0_6_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6556_ _2874_ _3339_ VGND VGND VPWR VPWR _3348_ sky130_fd_sc_hd__and2_1
X_3768_ memory\[4\]\[13\] memory\[5\]\[13\] memory\[6\]\[13\] memory\[7\]\[13\] _1360_
+ _1361_ VGND VGND VPWR VPWR _1461_ sky130_fd_sc_hd__mux4_1
XFILLER_0_42_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_104_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5507_ _2642_ _2779_ _2780_ net889 VGND VGND VPWR VPWR _0821_ sky130_fd_sc_hd__a22o_1
X_5533__10 clknet_1_1__leaf__2784_ VGND VGND VPWR VPWR net155 sky130_fd_sc_hd__inv_2
X_6487_ _3281_ VGND VGND VPWR VPWR _3308_ sky130_fd_sc_hd__clkbuf_2
X_3699_ memory\[24\]\[10\] memory\[25\]\[10\] memory\[26\]\[10\] memory\[27\]\[10\]
+ _1353_ _1354_ VGND VGND VPWR VPWR _1395_ sky130_fd_sc_hd__mux4_1
XFILLER_0_30_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5438_ _2483_ _2763_ _2764_ net369 VGND VGND VPWR VPWR _0768_ sky130_fd_sc_hd__a22o_1
XFILLER_0_100_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5369_ _2455_ _2749_ _2751_ net627 VGND VGND VPWR VPWR _0712_ sky130_fd_sc_hd__a22o_1
X_7108_ clknet_leaf_37_clk _0699_ VGND VGND VPWR VPWR memory\[29\]\[21\] sky130_fd_sc_hd__dfxtp_1
X_7039_ clknet_leaf_87_clk _0630_ VGND VGND VPWR VPWR memory\[16\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_69_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1013 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1002 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1035 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1046 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1024 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1079 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1068 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1057 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_107_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_116_clk clknet_4_0_0_clk VGND VGND VPWR VPWR clknet_leaf_116_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_122_147 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_122_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_110_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_808 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_819 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_113_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4740_ _2380_ _2382_ _2385_ _1797_ _2249_ VGND VGND VPWR VPWR _2386_ sky130_fd_sc_hd__a221o_1
XFILLER_0_7_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_leaf_107_clk clknet_4_1_0_clk VGND VGND VPWR VPWR clknet_leaf_107_clk sky130_fd_sc_hd__clkbuf_16
X_4671_ memory\[20\]\[25\] memory\[21\]\[25\] memory\[22\]\[25\] memory\[23\]\[25\]
+ _1866_ _1867_ VGND VGND VPWR VPWR _2320_ sky130_fd_sc_hd__mux4_1
XFILLER_0_71_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6410_ _3235_ VGND VGND VPWR VPWR _3263_ sky130_fd_sc_hd__clkbuf_4
X_3622_ memory\[8\]\[6\] memory\[9\]\[6\] memory\[10\]\[6\] memory\[11\]\[6\] _1188_
+ _1190_ VGND VGND VPWR VPWR _1322_ sky130_fd_sc_hd__mux4_1
X_7390_ clknet_leaf_90_clk _0949_ VGND VGND VPWR VPWR memory\[25\]\[15\] sky130_fd_sc_hd__dfxtp_1
X_6341_ _2642_ _3229_ _3230_ net836 VGND VGND VPWR VPWR _0180_ sky130_fd_sc_hd__a22o_1
XFILLER_0_113_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3553_ _1235_ _1256_ VGND VGND VPWR VPWR _1257_ sky130_fd_sc_hd__and2_1
X_3484_ _1189_ VGND VGND VPWR VPWR _1190_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_12_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6272_ net570 _3187_ _3196_ _3198_ VGND VGND VPWR VPWR _0143_ sky130_fd_sc_hd__a31o_1
X_5223_ _2471_ _2686_ _2687_ net994 VGND VGND VPWR VPWR _0630_ sky130_fd_sc_hd__a22o_1
X_5154_ _2648_ _2632_ VGND VGND VPWR VPWR _2649_ sky130_fd_sc_hd__and2_1
X_4105_ memory\[16\]\[31\] memory\[17\]\[31\] memory\[18\]\[31\] memory\[19\]\[31\]
+ _1157_ _1159_ VGND VGND VPWR VPWR _1780_ sky130_fd_sc_hd__mux4_1
X_5085_ memory\[6\]\[31\] _2597_ _2559_ VGND VGND VPWR VPWR _2599_ sky130_fd_sc_hd__and3_1
X_4036_ _1588_ _1714_ VGND VGND VPWR VPWR _1715_ sky130_fd_sc_hd__or2_1
XFILLER_0_79_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_66_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5987_ _2878_ _3023_ VGND VGND VPWR VPWR _3033_ sky130_fd_sc_hd__and2_1
X_7726_ clknet_leaf_45_clk _0260_ VGND VGND VPWR VPWR memory\[5\]\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_74_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4938_ _2439_ _2505_ _2514_ VGND VGND VPWR VPWR _0518_ sky130_fd_sc_hd__a21o_1
XFILLER_0_19_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4869_ _2483_ _2476_ _2477_ net326 VGND VGND VPWR VPWR _0479_ sky130_fd_sc_hd__a22o_1
X_7657_ clknet_leaf_33_clk _0191_ VGND VGND VPWR VPWR memory\[19\]\[26\] sky130_fd_sc_hd__dfxtp_1
XANTENNA_41 _2738_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_30 _2559_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_63 net50 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_52 _2911_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XANTENNA_74 net67 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6608_ _2636_ _3371_ _3372_ net317 VGND VGND VPWR VPWR _0305_ sky130_fd_sc_hd__a22o_1
XFILLER_0_105_659 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_7588_ clknet_leaf_18_clk _1147_ VGND VGND VPWR VPWR memory\[23\]\[21\] sky130_fd_sc_hd__dfxtp_1
XANTENNA_85 net94 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_96 _1812_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6539_ _3323_ VGND VGND VPWR VPWR _3338_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_113_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_108_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_68_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_68_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_21_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5910_ net367 _2981_ _2977_ _2988_ VGND VGND VPWR VPWR _1016_ sky130_fd_sc_hd__a31o_1
X_6890_ clknet_leaf_35_clk _0481_ VGND VGND VPWR VPWR memory\[28\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_76_627 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_48_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5841_ net1116 _2943_ _2947_ VGND VGND VPWR VPWR _2949_ sky130_fd_sc_hd__and3_1
XFILLER_0_118_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_118_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5772_ _2648_ _2913_ _2914_ net1003 VGND VGND VPWR VPWR _0920_ sky130_fd_sc_hd__a22o_1
X_4723_ _2361_ _2369_ VGND VGND VPWR VPWR _2370_ sky130_fd_sc_hd__and2_1
X_7511_ clknet_leaf_102_clk _1070_ VGND VGND VPWR VPWR memory\[11\]\[8\] sky130_fd_sc_hd__dfxtp_1
X_7442_ clknet_leaf_102_clk _1001_ VGND VGND VPWR VPWR memory\[1\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_114_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4654_ memory\[16\]\[24\] memory\[17\]\[24\] memory\[18\]\[24\] memory\[19\]\[24\]
+ _1800_ _1802_ VGND VGND VPWR VPWR _2304_ sky130_fd_sc_hd__mux4_1
XFILLER_0_4_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4585_ memory\[16\]\[20\] memory\[17\]\[20\] memory\[18\]\[20\] memory\[19\]\[20\]
+ _1970_ _1971_ VGND VGND VPWR VPWR _2239_ sky130_fd_sc_hd__mux4_1
X_7373_ clknet_leaf_18_clk _0932_ VGND VGND VPWR VPWR memory\[18\]\[30\] sky130_fd_sc_hd__dfxtp_1
Xhold812 memory\[14\]\[9\] VGND VGND VPWR VPWR net1021 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_71_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3605_ memory\[8\]\[5\] memory\[9\]\[5\] memory\[10\]\[5\] memory\[11\]\[5\] _1246_
+ _1247_ VGND VGND VPWR VPWR _1306_ sky130_fd_sc_hd__mux4_1
XFILLER_0_3_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold801 memory\[21\]\[19\] VGND VGND VPWR VPWR net1010 sky130_fd_sc_hd__dlygate4sd3_1
Xhold823 memory\[23\]\[13\] VGND VGND VPWR VPWR net1032 sky130_fd_sc_hd__dlygate4sd3_1
Xhold845 memory\[23\]\[1\] VGND VGND VPWR VPWR net1054 sky130_fd_sc_hd__dlygate4sd3_1
X_6324_ _2607_ _3226_ _3228_ net547 VGND VGND VPWR VPWR _0165_ sky130_fd_sc_hd__a22o_1
Xhold834 memory\[24\]\[1\] VGND VGND VPWR VPWR net1043 sky130_fd_sc_hd__dlygate4sd3_1
X_3536_ _1156_ VGND VGND VPWR VPWR _1240_ sky130_fd_sc_hd__clkbuf_8
Xhold878 memory\[5\]\[29\] VGND VGND VPWR VPWR net1087 sky130_fd_sc_hd__dlygate4sd3_1
Xhold867 memory\[12\]\[10\] VGND VGND VPWR VPWR net1076 sky130_fd_sc_hd__dlygate4sd3_1
X_6255_ _2842_ _3184_ VGND VGND VPWR VPWR _3189_ sky130_fd_sc_hd__and2_1
Xhold889 memory\[11\]\[7\] VGND VGND VPWR VPWR net1098 sky130_fd_sc_hd__dlygate4sd3_1
Xhold856 memory\[11\]\[12\] VGND VGND VPWR VPWR net1065 sky130_fd_sc_hd__dlygate4sd3_1
X_3467_ _1172_ VGND VGND VPWR VPWR _1173_ sky130_fd_sc_hd__buf_4
X_5206_ _2454_ _2683_ _2685_ net904 VGND VGND VPWR VPWR _0615_ sky130_fd_sc_hd__a22o_1
X_6186_ _2849_ _3140_ VGND VGND VPWR VPWR _3149_ sky130_fd_sc_hd__and2_1
X_5137_ net1072 _2629_ _2630_ _2637_ VGND VGND VPWR VPWR _0594_ sky130_fd_sc_hd__a31o_1
X_5068_ net1126 _2585_ _2586_ VGND VGND VPWR VPWR _2590_ sky130_fd_sc_hd__and3_1
X_4019_ memory\[28\]\[26\] memory\[29\]\[26\] memory\[30\]\[26\] memory\[31\]\[26\]
+ _1592_ _1593_ VGND VGND VPWR VPWR _1699_ sky130_fd_sc_hd__mux4_1
XFILLER_0_90_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7709_ clknet_leaf_84_clk _0243_ VGND VGND VPWR VPWR memory\[5\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_35_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_117_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_708 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_15_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_120_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_435 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_58_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_79_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_26_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold108 memory\[30\]\[12\] VGND VGND VPWR VPWR net317 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_110_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4370_ _1812_ _2034_ VGND VGND VPWR VPWR _2035_ sky130_fd_sc_hd__or2_1
Xhold119 memory\[31\]\[3\] VGND VGND VPWR VPWR net328 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6040_ _2855_ _3053_ VGND VGND VPWR VPWR _3064_ sky130_fd_sc_hd__and2_1
XTAP_446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6942_ clknet_leaf_74_clk _0533_ VGND VGND VPWR VPWR memory\[10\]\[15\] sky130_fd_sc_hd__dfxtp_1
X_6873_ clknet_leaf_78_clk _0464_ VGND VGND VPWR VPWR memory\[28\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_48_126 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5824_ memory\[25\]\[14\] _2930_ _2934_ VGND VGND VPWR VPWR _2939_ sky130_fd_sc_hd__and3_1
XFILLER_0_106_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5755_ _2615_ _2910_ _2912_ net761 VGND VGND VPWR VPWR _0905_ sky130_fd_sc_hd__a22o_1
XFILLER_0_115_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4706_ _2353_ VGND VGND VPWR VPWR _0050_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_72_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5686_ _2865_ _2859_ VGND VGND VPWR VPWR _2866_ sky130_fd_sc_hd__and2_1
XFILLER_0_32_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4637_ memory\[28\]\[23\] memory\[29\]\[23\] memory\[30\]\[23\] memory\[31\]\[23\]
+ _1960_ _1961_ VGND VGND VPWR VPWR _2288_ sky130_fd_sc_hd__mux4_1
XFILLER_0_114_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7425_ clknet_leaf_81_clk net127 VGND VGND VPWR VPWR memory\[0\]\[18\] sky130_fd_sc_hd__dfxtp_1
Xhold620 memory\[21\]\[20\] VGND VGND VPWR VPWR net829 sky130_fd_sc_hd__dlygate4sd3_1
Xhold631 memory\[3\]\[28\] VGND VGND VPWR VPWR net840 sky130_fd_sc_hd__dlygate4sd3_1
X_4568_ _1826_ VGND VGND VPWR VPWR _2223_ sky130_fd_sc_hd__buf_4
XFILLER_0_69_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7356_ clknet_leaf_92_clk _0915_ VGND VGND VPWR VPWR memory\[18\]\[13\] sky130_fd_sc_hd__dfxtp_1
Xhold642 memory\[22\]\[19\] VGND VGND VPWR VPWR net851 sky130_fd_sc_hd__dlygate4sd3_1
Xhold653 memory\[24\]\[19\] VGND VGND VPWR VPWR net862 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6307_ _2895_ _3210_ VGND VGND VPWR VPWR _3218_ sky130_fd_sc_hd__and2_1
Xhold697 memory\[15\]\[6\] VGND VGND VPWR VPWR net906 sky130_fd_sc_hd__dlygate4sd3_1
X_7287_ clknet_leaf_14_clk _0846_ VGND VGND VPWR VPWR memory\[8\]\[8\] sky130_fd_sc_hd__dfxtp_1
Xhold686 memory\[18\]\[9\] VGND VGND VPWR VPWR net895 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_5_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold675 memory\[21\]\[0\] VGND VGND VPWR VPWR net884 sky130_fd_sc_hd__dlygate4sd3_1
Xhold664 memory\[20\]\[17\] VGND VGND VPWR VPWR net873 sky130_fd_sc_hd__dlygate4sd3_1
X_3519_ memory\[0\]\[1\] memory\[1\]\[1\] memory\[2\]\[1\] memory\[3\]\[1\] _1202_
+ _1203_ VGND VGND VPWR VPWR _1224_ sky130_fd_sc_hd__mux4_1
X_4499_ memory\[8\]\[15\] memory\[9\]\[15\] memory\[10\]\[15\] memory\[11\]\[15\]
+ _1913_ _1914_ VGND VGND VPWR VPWR _2158_ sky130_fd_sc_hd__mux4_1
X_6238_ _2901_ _3167_ VGND VGND VPWR VPWR _3178_ sky130_fd_sc_hd__and2_1
XTAP_980 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6169_ _3137_ VGND VGND VPWR VPWR _3138_ sky130_fd_sc_hd__clkbuf_4
XTAP_991 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_96_clk clknet_4_4_0_clk VGND VGND VPWR VPWR clknet_leaf_96_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_82_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_20_clk clknet_4_8_0_clk VGND VGND VPWR VPWR clknet_leaf_20_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_105_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_87_clk clknet_4_5_0_clk VGND VGND VPWR VPWR clknet_leaf_87_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_81_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_85_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3870_ memory\[8\]\[18\] memory\[9\]\[18\] memory\[10\]\[18\] memory\[11\]\[18\]
+ _1202_ _1203_ VGND VGND VPWR VPWR _1558_ sky130_fd_sc_hd__mux4_1
XFILLER_0_39_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_11_clk clknet_4_3_0_clk VGND VGND VPWR VPWR clknet_leaf_11_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_121_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5471_ _2766_ VGND VGND VPWR VPWR _2772_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_26_376 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_7210_ clknet_leaf_37_clk _0801_ VGND VGND VPWR VPWR memory\[14\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_112_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_111_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4422_ _2076_ _2084_ VGND VGND VPWR VPWR _2085_ sky130_fd_sc_hd__and2_1
XFILLER_0_1_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7141_ clknet_leaf_62_clk _0732_ VGND VGND VPWR VPWR memory\[3\]\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_22_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4353_ memory\[0\]\[8\] memory\[1\]\[8\] memory\[2\]\[8\] memory\[3\]\[8\] _2017_
+ _2018_ VGND VGND VPWR VPWR _2019_ sky130_fd_sc_hd__mux4_1
X_4284_ _1836_ _1952_ _1840_ VGND VGND VPWR VPWR _1953_ sky130_fd_sc_hd__o21a_1
X_7072_ clknet_leaf_83_clk _0663_ VGND VGND VPWR VPWR memory\[4\]\[17\] sky130_fd_sc_hd__dfxtp_1
X_6023_ _2838_ _3053_ VGND VGND VPWR VPWR _3055_ sky130_fd_sc_hd__and2_1
XTAP_254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_78_clk clknet_4_6_0_clk VGND VGND VPWR VPWR clknet_leaf_78_clk sky130_fd_sc_hd__clkbuf_16
XTAP_1409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6925_ clknet_leaf_40_clk _0516_ VGND VGND VPWR VPWR memory\[15\]\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_12_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_91_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3999_ memory\[24\]\[25\] memory\[25\]\[25\] memory\[26\]\[25\] memory\[27\]\[25\]
+ _1551_ _1552_ VGND VGND VPWR VPWR _1680_ sky130_fd_sc_hd__mux4_1
X_6787_ _2442_ _2736_ _2907_ VGND VGND VPWR VPWR _3436_ sky130_fd_sc_hd__and3_1
X_5807_ net1119 _2597_ _2921_ VGND VGND VPWR VPWR _2929_ sky130_fd_sc_hd__and3_1
X_5738_ _2901_ _2882_ VGND VGND VPWR VPWR _2902_ sky130_fd_sc_hd__and2_1
X_5669_ _2853_ _2836_ VGND VGND VPWR VPWR _2854_ sky130_fd_sc_hd__and2_1
XFILLER_0_60_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7408_ clknet_leaf_107_clk net144 VGND VGND VPWR VPWR memory\[0\]\[1\] sky130_fd_sc_hd__dfxtp_1
Xhold450 memory\[17\]\[22\] VGND VGND VPWR VPWR net659 sky130_fd_sc_hd__dlygate4sd3_1
X_7339_ clknet_leaf_46_clk _0898_ VGND VGND VPWR VPWR memory\[7\]\[28\] sky130_fd_sc_hd__dfxtp_1
Xhold472 memory\[13\]\[10\] VGND VGND VPWR VPWR net681 sky130_fd_sc_hd__dlygate4sd3_1
Xhold461 memory\[2\]\[13\] VGND VGND VPWR VPWR net670 sky130_fd_sc_hd__dlygate4sd3_1
Xhold494 memory\[3\]\[25\] VGND VGND VPWR VPWR net703 sky130_fd_sc_hd__dlygate4sd3_1
Xhold483 memory\[20\]\[23\] VGND VGND VPWR VPWR net692 sky130_fd_sc_hd__dlygate4sd3_1
Xclkbuf_leaf_69_clk clknet_4_13_0_clk VGND VGND VPWR VPWR clknet_leaf_69_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_95_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_633 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_106_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_184 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_51_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_121_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_0_clk clknet_4_0_0_clk VGND VGND VPWR VPWR clknet_leaf_0_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_92_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4971_ _2469_ _2525_ _2533_ VGND VGND VPWR VPWR _0532_ sky130_fd_sc_hd__a21o_1
X_3922_ _1598_ _1607_ VGND VGND VPWR VPWR _1608_ sky130_fd_sc_hd__and2_1
X_7690_ clknet_leaf_24_clk _0224_ VGND VGND VPWR VPWR memory\[21\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_86_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6710_ net22 _3401_ VGND VGND VPWR VPWR _3408_ sky130_fd_sc_hd__and2_1
X_3853_ memory\[12\]\[17\] memory\[13\]\[17\] memory\[14\]\[17\] memory\[15\]\[17\]
+ _1430_ _1431_ VGND VGND VPWR VPWR _1542_ sky130_fd_sc_hd__mux4_1
XFILLER_0_73_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6641_ _2621_ _3377_ _3379_ net542 VGND VGND VPWR VPWR _0331_ sky130_fd_sc_hd__a22o_1
X_6572_ _2891_ _3352_ VGND VGND VPWR VPWR _3357_ sky130_fd_sc_hd__and2_1
XFILLER_0_73_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3784_ memory\[28\]\[14\] memory\[29\]\[14\] memory\[30\]\[14\] memory\[31\]\[14\]
+ _1398_ _1399_ VGND VGND VPWR VPWR _1476_ sky130_fd_sc_hd__mux4_1
XFILLER_0_42_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5523_ _2673_ _2781_ _2782_ net341 VGND VGND VPWR VPWR _0835_ sky130_fd_sc_hd__a22o_1
XFILLER_0_26_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5454_ _2458_ _2767_ _2769_ net410 VGND VGND VPWR VPWR _0779_ sky130_fd_sc_hd__a22o_1
X_5385_ _2471_ _2752_ _2753_ net244 VGND VGND VPWR VPWR _0726_ sky130_fd_sc_hd__a22o_1
XFILLER_0_1_251 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_41_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4405_ _2068_ VGND VGND VPWR VPWR _0033_ sky130_fd_sc_hd__clkbuf_1
X_7124_ clknet_leaf_105_clk _0715_ VGND VGND VPWR VPWR memory\[3\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_4336_ _2001_ _2002_ _1848_ VGND VGND VPWR VPWR _2003_ sky130_fd_sc_hd__mux2_1
XFILLER_0_5_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_7055_ clknet_leaf_112_clk _0646_ VGND VGND VPWR VPWR memory\[4\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_4267_ _1928_ _1936_ VGND VGND VPWR VPWR _1937_ sky130_fd_sc_hd__and2_1
X_6006_ _2897_ _3036_ VGND VGND VPWR VPWR _3044_ sky130_fd_sc_hd__and2_1
X_4198_ _1811_ VGND VGND VPWR VPWR _1871_ sky130_fd_sc_hd__buf_4
XFILLER_0_82_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_77_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6908_ clknet_leaf_67_clk _0499_ VGND VGND VPWR VPWR memory\[15\]\[14\] sky130_fd_sc_hd__dfxtp_1
X_7888_ clknet_leaf_112_clk _0422_ VGND VGND VPWR VPWR memory\[17\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_49_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_49_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_92_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_511 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_119_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_107_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_717 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_64_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_103_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold280 memory\[15\]\[8\] VGND VGND VPWR VPWR net489 sky130_fd_sc_hd__dlygate4sd3_1
Xhold291 memory\[21\]\[10\] VGND VGND VPWR VPWR net500 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_87_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_142 net90 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_120 _2886_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_131 _2918_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_1751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_153 _3437_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_1784 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1773 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_427 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_28_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1795 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_246 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_36_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_106_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_23_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5170_ net1038 _2652_ _2653_ _2660_ VGND VGND VPWR VPWR _0604_ sky130_fd_sc_hd__a31o_1
X_4121_ _1795_ VGND VGND VPWR VPWR _0024_ sky130_fd_sc_hd__clkbuf_1
X_4052_ _1728_ _1729_ _1176_ VGND VGND VPWR VPWR _1730_ sky130_fd_sc_hd__mux2_1
Xinput4 data_addr1[3] VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__buf_2
XFILLER_0_36_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7811_ clknet_leaf_59_clk _0345_ VGND VGND VPWR VPWR memory\[12\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_86_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4954_ memory\[10\]\[8\] _2516_ _2513_ VGND VGND VPWR VPWR _2523_ sky130_fd_sc_hd__and3_1
XFILLER_0_59_574 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_7742_ clknet_leaf_95_clk _0276_ VGND VGND VPWR VPWR memory\[22\]\[15\] sky130_fd_sc_hd__dfxtp_1
X_3905_ _1243_ VGND VGND VPWR VPWR _1591_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_19_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4885_ _2493_ VGND VGND VPWR VPWR _2494_ sky130_fd_sc_hd__buf_4
X_7673_ clknet_leaf_94_clk _0207_ VGND VGND VPWR VPWR memory\[21\]\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_46_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6624_ _2667_ _3373_ _3374_ net356 VGND VGND VPWR VPWR _0319_ sky130_fd_sc_hd__a22o_1
XFILLER_0_117_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_116_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3836_ _1486_ _1525_ _1488_ VGND VGND VPWR VPWR _1526_ sky130_fd_sc_hd__o21a_1
XFILLER_0_15_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_644 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6555_ net1102 _3346_ _3338_ _3347_ VGND VGND VPWR VPWR _0277_ sky130_fd_sc_hd__a31o_1
X_3767_ _1390_ _1455_ _1457_ _1459_ _1403_ VGND VGND VPWR VPWR _1460_ sky130_fd_sc_hd__a221o_1
X_5506_ _2640_ _2779_ _2780_ net550 VGND VGND VPWR VPWR _0820_ sky130_fd_sc_hd__a22o_1
X_6486_ _3279_ VGND VGND VPWR VPWR _3307_ sky130_fd_sc_hd__clkbuf_4
X_3698_ _1168_ VGND VGND VPWR VPWR _1394_ sky130_fd_sc_hd__buf_2
XFILLER_0_112_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5437_ _2482_ _2763_ _2764_ net467 VGND VGND VPWR VPWR _0767_ sky130_fd_sc_hd__a22o_1
XFILLER_0_77_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5368_ _2454_ _2749_ _2751_ net531 VGND VGND VPWR VPWR _0711_ sky130_fd_sc_hd__a22o_1
X_7107_ clknet_leaf_38_clk _0698_ VGND VGND VPWR VPWR memory\[29\]\[20\] sky130_fd_sc_hd__dfxtp_1
X_5299_ _2661_ _2721_ VGND VGND VPWR VPWR _2725_ sky130_fd_sc_hd__and2_1
X_4319_ _1981_ _1983_ _1986_ _1850_ _1851_ VGND VGND VPWR VPWR _1987_ sky130_fd_sc_hd__a221o_1
X_7038_ clknet_leaf_88_clk _0629_ VGND VGND VPWR VPWR memory\[16\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_97_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_69_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1003 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1036 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1047 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1025 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1014 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1069 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1058 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_122_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_482 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_21_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_122_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_809 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_714 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_56_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4670_ _2319_ VGND VGND VPWR VPWR _0048_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_28_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_118_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_114_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3621_ _1155_ _1316_ _1318_ _1320_ _1184_ VGND VGND VPWR VPWR _1321_ sky130_fd_sc_hd__a221o_1
X_6340_ _2640_ _3229_ _3230_ net563 VGND VGND VPWR VPWR _0179_ sky130_fd_sc_hd__a22o_1
XFILLER_0_3_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3552_ _1236_ _1244_ _1249_ _1255_ _1208_ VGND VGND VPWR VPWR _1256_ sky130_fd_sc_hd__a221o_1
XFILLER_0_24_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_122_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6271_ _2858_ _3197_ VGND VGND VPWR VPWR _3198_ sky130_fd_sc_hd__and2_1
X_3483_ net7 VGND VGND VPWR VPWR _1189_ sky130_fd_sc_hd__buf_4
XFILLER_0_121_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5222_ _2470_ _2686_ _2687_ net921 VGND VGND VPWR VPWR _0629_ sky130_fd_sc_hd__a22o_1
X_5153_ net25 VGND VGND VPWR VPWR _2648_ sky130_fd_sc_hd__buf_4
X_4104_ memory\[20\]\[31\] memory\[21\]\[31\] memory\[22\]\[31\] memory\[23\]\[31\]
+ _1240_ _1241_ VGND VGND VPWR VPWR _1779_ sky130_fd_sc_hd__mux4_1
X_5084_ _2487_ _2555_ _2598_ VGND VGND VPWR VPWR _0580_ sky130_fd_sc_hd__a21o_1
X_4035_ memory\[24\]\[27\] memory\[25\]\[27\] memory\[26\]\[27\] memory\[27\]\[27\]
+ _1551_ _1552_ VGND VGND VPWR VPWR _1714_ sky130_fd_sc_hd__mux4_1
XFILLER_0_63_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_63_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_680 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5986_ net389 _3021_ _3022_ _3032_ VGND VGND VPWR VPWR _1048_ sky130_fd_sc_hd__a31o_1
XFILLER_0_47_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7725_ clknet_leaf_47_clk _0259_ VGND VGND VPWR VPWR memory\[5\]\[30\] sky130_fd_sc_hd__dfxtp_1
X_4937_ memory\[10\]\[0\] _2509_ _2513_ VGND VGND VPWR VPWR _2514_ sky130_fd_sc_hd__and3_1
X_4868_ net34 VGND VGND VPWR VPWR _2483_ sky130_fd_sc_hd__buf_4
X_7656_ clknet_leaf_32_clk _0190_ VGND VGND VPWR VPWR memory\[19\]\[25\] sky130_fd_sc_hd__dfxtp_1
XANTENNA_20 _1964_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_19_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_31 _2621_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_75 net68 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_53 _2920_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XANTENNA_64 net53 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3819_ _1156_ VGND VGND VPWR VPWR _1509_ sky130_fd_sc_hd__buf_6
X_6607_ _2634_ _3371_ _3372_ net1080 VGND VGND VPWR VPWR _0304_ sky130_fd_sc_hd__a22o_1
XANTENNA_42 _2740_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_104_126 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XANTENNA_97 _1819_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7587_ clknet_leaf_18_clk _1146_ VGND VGND VPWR VPWR memory\[23\]\[20\] sky130_fd_sc_hd__dfxtp_1
X_4799_ net15 net14 net13 VGND VGND VPWR VPWR _2441_ sky130_fd_sc_hd__or3_4
XANTENNA_86 net95 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_104_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6538_ net483 _3333_ _3324_ _3337_ VGND VGND VPWR VPWR _0270_ sky130_fd_sc_hd__a31o_1
XFILLER_0_15_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6469_ _2863_ _3295_ VGND VGND VPWR VPWR _3298_ sky130_fd_sc_hd__and2_1
XFILLER_0_30_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_30_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_69_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_104_9 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_41_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_53_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_108_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5840_ _2475_ _2946_ _2948_ VGND VGND VPWR VPWR _0954_ sky130_fd_sc_hd__a21o_1
XFILLER_0_76_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5771_ _2646_ _2913_ _2914_ net668 VGND VGND VPWR VPWR _0919_ sky130_fd_sc_hd__a22o_1
X_4722_ _1850_ _2364_ _2366_ _2368_ _2249_ VGND VGND VPWR VPWR _2369_ sky130_fd_sc_hd__a221o_1
XFILLER_0_56_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7510_ clknet_leaf_104_clk _1069_ VGND VGND VPWR VPWR memory\[11\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_44_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7441_ clknet_leaf_102_clk _1000_ VGND VGND VPWR VPWR memory\[1\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_4653_ memory\[20\]\[24\] memory\[21\]\[24\] memory\[22\]\[24\] memory\[23\]\[24\]
+ _1866_ _1867_ VGND VGND VPWR VPWR _2303_ sky130_fd_sc_hd__mux4_1
Xinput40 data_in[31] VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__buf_2
X_7372_ clknet_leaf_33_clk _0931_ VGND VGND VPWR VPWR memory\[18\]\[29\] sky130_fd_sc_hd__dfxtp_1
X_4584_ memory\[20\]\[20\] memory\[21\]\[20\] memory\[22\]\[20\] memory\[23\]\[20\]
+ _1831_ _1833_ VGND VGND VPWR VPWR _2238_ sky130_fd_sc_hd__mux4_1
Xhold802 memory\[27\]\[14\] VGND VGND VPWR VPWR net1011 sky130_fd_sc_hd__dlygate4sd3_1
X_3604_ _1303_ _1304_ _1243_ VGND VGND VPWR VPWR _1305_ sky130_fd_sc_hd__mux2_1
XFILLER_0_101_118 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold835 memory\[7\]\[25\] VGND VGND VPWR VPWR net1044 sky130_fd_sc_hd__dlygate4sd3_1
Xhold846 memory\[8\]\[9\] VGND VGND VPWR VPWR net1055 sky130_fd_sc_hd__dlygate4sd3_1
Xhold813 memory\[8\]\[14\] VGND VGND VPWR VPWR net1022 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_4_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6323_ _3227_ VGND VGND VPWR VPWR _3228_ sky130_fd_sc_hd__clkbuf_4
X_3535_ memory\[4\]\[2\] memory\[5\]\[2\] memory\[6\]\[2\] memory\[7\]\[2\] _1237_
+ _1238_ VGND VGND VPWR VPWR _1239_ sky130_fd_sc_hd__mux4_1
Xhold824 memory\[11\]\[15\] VGND VGND VPWR VPWR net1033 sky130_fd_sc_hd__dlygate4sd3_1
Xhold879 memory\[9\]\[7\] VGND VGND VPWR VPWR net1088 sky130_fd_sc_hd__dlygate4sd3_1
X_6254_ net1077 _3187_ _3182_ _3188_ VGND VGND VPWR VPWR _0135_ sky130_fd_sc_hd__a31o_1
Xhold868 memory\[27\]\[2\] VGND VGND VPWR VPWR net1077 sky130_fd_sc_hd__dlygate4sd3_1
X_3466_ net7 VGND VGND VPWR VPWR _1172_ sky130_fd_sc_hd__buf_6
Xhold857 memory\[9\]\[0\] VGND VGND VPWR VPWR net1066 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_110_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5205_ _2439_ _2683_ _2685_ net214 VGND VGND VPWR VPWR _0614_ sky130_fd_sc_hd__a22o_1
X_6185_ net599 _3146_ _3138_ _3148_ VGND VGND VPWR VPWR _1131_ sky130_fd_sc_hd__a31o_1
X_6854__61 clknet_1_0__leaf__3446_ VGND VGND VPWR VPWR net206 sky130_fd_sc_hd__inv_2
X_5136_ _2636_ _2632_ VGND VGND VPWR VPWR _2637_ sky130_fd_sc_hd__and2_1
X_5067_ _2479_ _2584_ _2589_ VGND VGND VPWR VPWR _0572_ sky130_fd_sc_hd__a21o_1
X_4018_ _1588_ _1697_ VGND VGND VPWR VPWR _1698_ sky130_fd_sc_hd__or2_1
XFILLER_0_94_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_79_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_109_207 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_75_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5969_ _2858_ _3023_ VGND VGND VPWR VPWR _3024_ sky130_fd_sc_hd__and2_1
X_7708_ clknet_leaf_87_clk _0242_ VGND VGND VPWR VPWR memory\[5\]\[13\] sky130_fd_sc_hd__dfxtp_1
X_7639_ clknet_leaf_111_clk _0173_ VGND VGND VPWR VPWR memory\[19\]\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_35_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_672 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold109 memory\[30\]\[6\] VGND VGND VPWR VPWR net318 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_95_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_119_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6941_ clknet_leaf_68_clk _0532_ VGND VGND VPWR VPWR memory\[10\]\[14\] sky130_fd_sc_hd__dfxtp_1
X_6872_ clknet_leaf_77_clk _0463_ VGND VGND VPWR VPWR memory\[28\]\[10\] sky130_fd_sc_hd__dfxtp_1
X_5823_ _2468_ _2933_ _2938_ VGND VGND VPWR VPWR _0947_ sky130_fd_sc_hd__a21o_1
XFILLER_0_48_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_63_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5754_ _2613_ _2910_ _2912_ net825 VGND VGND VPWR VPWR _0904_ sky130_fd_sc_hd__a22o_1
X_4705_ _2344_ _2352_ VGND VGND VPWR VPWR _2353_ sky130_fd_sc_hd__and2_1
X_5685_ net20 VGND VGND VPWR VPWR _2865_ sky130_fd_sc_hd__buf_4
X_4636_ _1871_ _2286_ VGND VGND VPWR VPWR _2287_ sky130_fd_sc_hd__or2_1
XFILLER_0_72_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7424_ clknet_leaf_68_clk net128 VGND VGND VPWR VPWR memory\[0\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_8_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_44_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold621 memory\[1\]\[24\] VGND VGND VPWR VPWR net830 sky130_fd_sc_hd__dlygate4sd3_1
Xhold610 memory\[21\]\[26\] VGND VGND VPWR VPWR net819 sky130_fd_sc_hd__dlygate4sd3_1
X_7355_ clknet_leaf_89_clk _0914_ VGND VGND VPWR VPWR memory\[18\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_4_463 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6306_ net766 _3213_ _3209_ _3217_ VGND VGND VPWR VPWR _0158_ sky130_fd_sc_hd__a31o_1
Xhold643 memory\[7\]\[31\] VGND VGND VPWR VPWR net852 sky130_fd_sc_hd__dlygate4sd3_1
Xhold632 memory\[17\]\[31\] VGND VGND VPWR VPWR net841 sky130_fd_sc_hd__dlygate4sd3_1
Xhold654 memory\[20\]\[18\] VGND VGND VPWR VPWR net863 sky130_fd_sc_hd__dlygate4sd3_1
X_4567_ _2116_ _2221_ _2118_ VGND VGND VPWR VPWR _2222_ sky130_fd_sc_hd__o21a_1
Xhold687 memory\[20\]\[24\] VGND VGND VPWR VPWR net896 sky130_fd_sc_hd__dlygate4sd3_1
X_7286_ clknet_leaf_43_clk _0845_ VGND VGND VPWR VPWR memory\[8\]\[7\] sky130_fd_sc_hd__dfxtp_1
Xhold676 memory\[5\]\[5\] VGND VGND VPWR VPWR net885 sky130_fd_sc_hd__dlygate4sd3_1
Xhold665 memory\[24\]\[7\] VGND VGND VPWR VPWR net874 sky130_fd_sc_hd__dlygate4sd3_1
X_3518_ memory\[4\]\[1\] memory\[5\]\[1\] memory\[6\]\[1\] memory\[7\]\[1\] _1199_
+ _1200_ VGND VGND VPWR VPWR _1223_ sky130_fd_sc_hd__mux4_1
X_4498_ _2155_ _2156_ _1869_ VGND VGND VPWR VPWR _2157_ sky130_fd_sc_hd__mux2_1
X_6237_ net899 _3172_ _3166_ _3177_ VGND VGND VPWR VPWR _0129_ sky130_fd_sc_hd__a31o_1
Xhold698 memory\[5\]\[19\] VGND VGND VPWR VPWR net907 sky130_fd_sc_hd__dlygate4sd3_1
X_3449_ _1154_ VGND VGND VPWR VPWR _1155_ sky130_fd_sc_hd__clkbuf_4
X_6168_ _2831_ _3093_ VGND VGND VPWR VPWR _3137_ sky130_fd_sc_hd__nand2_4
XTAP_970 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_992 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_981 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5119_ net1035 _2601_ _2606_ _2624_ VGND VGND VPWR VPWR _0589_ sky130_fd_sc_hd__a31o_1
X_6099_ _2838_ _3097_ VGND VGND VPWR VPWR _3099_ sky130_fd_sc_hd__and2_1
XFILLER_0_95_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_67_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_105_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_105_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6833__42 clknet_1_1__leaf__2787_ VGND VGND VPWR VPWR net187 sky130_fd_sc_hd__inv_2
XFILLER_0_81_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5470_ _2474_ _2770_ _2771_ net355 VGND VGND VPWR VPWR _0793_ sky130_fd_sc_hd__a22o_1
XFILLER_0_26_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_112_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_100_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4421_ _1862_ _2079_ _2081_ _2083_ _2066_ VGND VGND VPWR VPWR _2084_ sky130_fd_sc_hd__a221o_1
XFILLER_0_41_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_7140_ clknet_leaf_62_clk _0731_ VGND VGND VPWR VPWR memory\[3\]\[21\] sky130_fd_sc_hd__dfxtp_1
X_4352_ _1801_ VGND VGND VPWR VPWR _2018_ sky130_fd_sc_hd__buf_4
X_4283_ memory\[12\]\[5\] memory\[13\]\[5\] memory\[14\]\[5\] memory\[15\]\[5\] _1837_
+ _1838_ VGND VGND VPWR VPWR _1952_ sky130_fd_sc_hd__mux4_1
X_7071_ clknet_leaf_84_clk _0662_ VGND VGND VPWR VPWR memory\[4\]\[16\] sky130_fd_sc_hd__dfxtp_1
XTAP_255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6022_ net856 _3047_ _3051_ _3054_ VGND VGND VPWR VPWR _1062_ sky130_fd_sc_hd__a31o_1
XTAP_277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6924_ clknet_leaf_46_clk _0515_ VGND VGND VPWR VPWR memory\[15\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_76_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_107_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3998_ _1677_ _1678_ _1176_ VGND VGND VPWR VPWR _1679_ sky130_fd_sc_hd__mux2_1
X_6786_ _2678_ _3428_ _3430_ net254 VGND VGND VPWR VPWR _0420_ sky130_fd_sc_hd__a22o_1
X_5806_ _2459_ _2919_ _2928_ VGND VGND VPWR VPWR _0940_ sky130_fd_sc_hd__a21o_1
X_5737_ net37 VGND VGND VPWR VPWR _2901_ sky130_fd_sc_hd__buf_4
XFILLER_0_44_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7407_ clknet_leaf_13_clk net145 VGND VGND VPWR VPWR memory\[0\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_5668_ net46 VGND VGND VPWR VPWR _2853_ sky130_fd_sc_hd__clkbuf_4
X_4619_ _2269_ _2270_ _1819_ VGND VGND VPWR VPWR _2271_ sky130_fd_sc_hd__mux2_1
X_5599_ net1022 _2798_ _2803_ _2809_ VGND VGND VPWR VPWR _0852_ sky130_fd_sc_hd__a31o_1
XFILLER_0_13_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7338_ clknet_leaf_47_clk _0897_ VGND VGND VPWR VPWR memory\[7\]\[27\] sky130_fd_sc_hd__dfxtp_1
Xhold440 memory\[27\]\[31\] VGND VGND VPWR VPWR net649 sky130_fd_sc_hd__dlygate4sd3_1
Xhold462 memory\[15\]\[4\] VGND VGND VPWR VPWR net671 sky130_fd_sc_hd__dlygate4sd3_1
Xhold451 memory\[16\]\[13\] VGND VGND VPWR VPWR net660 sky130_fd_sc_hd__dlygate4sd3_1
Xhold473 memory\[27\]\[26\] VGND VGND VPWR VPWR net682 sky130_fd_sc_hd__dlygate4sd3_1
X_7269_ net172 _0014_ VGND VGND VPWR VPWR net96 sky130_fd_sc_hd__dfxtp_2
Xhold484 memory\[29\]\[8\] VGND VGND VPWR VPWR net693 sky130_fd_sc_hd__dlygate4sd3_1
Xhold495 memory\[27\]\[11\] VGND VGND VPWR VPWR net704 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_95_531 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_67_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_51_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_121_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_11_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_121_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4970_ memory\[10\]\[14\] _2530_ _2526_ VGND VGND VPWR VPWR _2533_ sky130_fd_sc_hd__and3_1
XFILLER_0_58_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3921_ _1479_ _1601_ _1603_ _1605_ _1606_ VGND VGND VPWR VPWR _1607_ sky130_fd_sc_hd__a221o_1
X_3852_ _1483_ _1540_ VGND VGND VPWR VPWR _1541_ sky130_fd_sc_hd__or2_1
X_6640_ _2619_ _3377_ _3379_ net556 VGND VGND VPWR VPWR _0330_ sky130_fd_sc_hd__a22o_1
XFILLER_0_46_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6571_ net1085 _3346_ _3351_ _3356_ VGND VGND VPWR VPWR _0284_ sky130_fd_sc_hd__a31o_1
XFILLER_0_73_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5522_ _2671_ _2781_ _2782_ net551 VGND VGND VPWR VPWR _0834_ sky130_fd_sc_hd__a22o_1
XFILLER_0_26_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3783_ _1394_ _1474_ VGND VGND VPWR VPWR _1475_ sky130_fd_sc_hd__or2_1
XFILLER_0_41_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_112_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5453_ _2457_ _2767_ _2769_ net678 VGND VGND VPWR VPWR _0778_ sky130_fd_sc_hd__a22o_1
X_5384_ _2470_ _2752_ _2753_ net293 VGND VGND VPWR VPWR _0725_ sky130_fd_sc_hd__a22o_1
X_4404_ _2058_ _2067_ VGND VGND VPWR VPWR _2068_ sky130_fd_sc_hd__and2_1
XFILLER_0_1_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7123_ clknet_leaf_112_clk _0714_ VGND VGND VPWR VPWR memory\[3\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_4335_ memory\[0\]\[7\] memory\[1\]\[7\] memory\[2\]\[7\] memory\[3\]\[7\] _1845_
+ _1846_ VGND VGND VPWR VPWR _2002_ sky130_fd_sc_hd__mux4_1
X_7054_ clknet_leaf_43_clk _0645_ VGND VGND VPWR VPWR memory\[16\]\[31\] sky130_fd_sc_hd__dfxtp_1
X_4266_ _1862_ _1931_ _1933_ _1935_ _1851_ VGND VGND VPWR VPWR _1936_ sky130_fd_sc_hd__a221o_1
X_6005_ net844 _3034_ _3035_ _3043_ VGND VGND VPWR VPWR _1056_ sky130_fd_sc_hd__a31o_1
X_4197_ _1865_ _1868_ _1869_ VGND VGND VPWR VPWR _1870_ sky130_fd_sc_hd__mux2_1
XFILLER_0_96_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6907_ clknet_leaf_67_clk _0498_ VGND VGND VPWR VPWR memory\[15\]\[13\] sky130_fd_sc_hd__dfxtp_1
X_7887_ clknet_leaf_0_clk _0421_ VGND VGND VPWR VPWR memory\[17\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_92_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6769_ _2644_ _3432_ _3433_ net231 VGND VGND VPWR VPWR _0405_ sky130_fd_sc_hd__a22o_1
XFILLER_0_103_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold270 memory\[11\]\[31\] VGND VGND VPWR VPWR net479 sky130_fd_sc_hd__dlygate4sd3_1
Xhold281 memory\[26\]\[24\] VGND VGND VPWR VPWR net490 sky130_fd_sc_hd__dlygate4sd3_1
Xhold292 memory\[5\]\[20\] VGND VGND VPWR VPWR net501 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_99_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_87_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_143 net91 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_121 _2886_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_110 _2438_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_132 _3181_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_1752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_154 _3437_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_1785 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1774 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1796 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4120_ _1786_ _1794_ VGND VGND VPWR VPWR _1795_ sky130_fd_sc_hd__and2_1
X_4051_ memory\[16\]\[28\] memory\[17\]\[28\] memory\[18\]\[28\] memory\[19\]\[28\]
+ _1157_ _1159_ VGND VGND VPWR VPWR _1729_ sky130_fd_sc_hd__mux4_1
Xinput5 data_addr1[4] VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__buf_4
XFILLER_0_36_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7810_ clknet_leaf_66_clk _0344_ VGND VGND VPWR VPWR memory\[12\]\[19\] sky130_fd_sc_hd__dfxtp_1
X_4953_ _2460_ _2505_ _2522_ VGND VGND VPWR VPWR _0525_ sky130_fd_sc_hd__a21o_1
X_7741_ clknet_leaf_109_clk _0275_ VGND VGND VPWR VPWR memory\[22\]\[14\] sky130_fd_sc_hd__dfxtp_1
X_3904_ _1588_ _1589_ VGND VGND VPWR VPWR _1590_ sky130_fd_sc_hd__or2_1
XFILLER_0_59_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7672_ clknet_leaf_111_clk _0206_ VGND VGND VPWR VPWR memory\[21\]\[9\] sky130_fd_sc_hd__dfxtp_1
X_6623_ _2665_ _3373_ _3374_ net512 VGND VGND VPWR VPWR _0318_ sky130_fd_sc_hd__a22o_1
X_4884_ _2492_ VGND VGND VPWR VPWR _2493_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_74_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_117_647 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3835_ memory\[12\]\[16\] memory\[13\]\[16\] memory\[14\]\[16\] memory\[15\]\[16\]
+ _1430_ _1431_ VGND VGND VPWR VPWR _1525_ sky130_fd_sc_hd__mux4_1
XFILLER_0_61_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6554_ _2872_ _3339_ VGND VGND VPWR VPWR _3347_ sky130_fd_sc_hd__and2_1
X_3766_ _1397_ _1458_ _1401_ VGND VGND VPWR VPWR _1459_ sky130_fd_sc_hd__o21a_1
XFILLER_0_27_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6485_ net907 _3304_ _3294_ _3306_ VGND VGND VPWR VPWR _0248_ sky130_fd_sc_hd__a31o_1
XFILLER_0_15_656 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5505_ _2638_ _2779_ _2780_ net946 VGND VGND VPWR VPWR _0819_ sky130_fd_sc_hd__a22o_1
XFILLER_0_42_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5436_ _2481_ _2763_ _2764_ net307 VGND VGND VPWR VPWR _0766_ sky130_fd_sc_hd__a22o_1
XFILLER_0_72_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3697_ _1391_ _1392_ _1279_ VGND VGND VPWR VPWR _1393_ sky130_fd_sc_hd__mux2_1
XFILLER_0_112_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5367_ _2439_ _2749_ _2751_ net447 VGND VGND VPWR VPWR _0710_ sky130_fd_sc_hd__a22o_1
X_5298_ net705 _2717_ _2720_ _2724_ VGND VGND VPWR VPWR _0668_ sky130_fd_sc_hd__a31o_1
X_7106_ clknet_leaf_85_clk _0697_ VGND VGND VPWR VPWR memory\[29\]\[19\] sky130_fd_sc_hd__dfxtp_1
X_4318_ _1984_ _1985_ _1848_ VGND VGND VPWR VPWR _1986_ sky130_fd_sc_hd__mux2_1
X_4249_ _1909_ _1919_ VGND VGND VPWR VPWR _1920_ sky130_fd_sc_hd__and2_1
X_7037_ clknet_leaf_88_clk _0628_ VGND VGND VPWR VPWR memory\[16\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_97_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1004 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7939_ net202 _0044_ VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__dfxtp_1
XTAP_1037 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1026 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1015 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_1059 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1048 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_107_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_92_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_122_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_113_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_98_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_43_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3620_ _1177_ _1319_ _1181_ VGND VGND VPWR VPWR _1320_ sky130_fd_sc_hd__o21a_1
X_3551_ _1250_ _1253_ _1254_ VGND VGND VPWR VPWR _1255_ sky130_fd_sc_hd__o21a_1
X_3482_ _1187_ VGND VGND VPWR VPWR _1188_ sky130_fd_sc_hd__buf_6
X_6270_ _3183_ VGND VGND VPWR VPWR _3197_ sky130_fd_sc_hd__buf_2
XFILLER_0_11_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5221_ _2469_ _2686_ _2687_ net1086 VGND VGND VPWR VPWR _0628_ sky130_fd_sc_hd__a22o_1
XFILLER_0_20_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5152_ net716 _2629_ _2630_ _2647_ VGND VGND VPWR VPWR _0599_ sky130_fd_sc_hd__a31o_1
X_4103_ _1778_ VGND VGND VPWR VPWR _0023_ sky130_fd_sc_hd__clkbuf_1
X_5083_ net1131 _2597_ _2559_ VGND VGND VPWR VPWR _2598_ sky130_fd_sc_hd__and3_1
X_4034_ _1711_ _1712_ _1176_ VGND VGND VPWR VPWR _1713_ sky130_fd_sc_hd__mux2_1
XFILLER_0_63_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_7724_ clknet_leaf_49_clk _0258_ VGND VGND VPWR VPWR memory\[5\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_59_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5985_ _2876_ _3023_ VGND VGND VPWR VPWR _3032_ sky130_fd_sc_hd__and2_1
XFILLER_0_47_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4936_ _2512_ VGND VGND VPWR VPWR _2513_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_74_320 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_19_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4867_ _2482_ _2476_ _2477_ net580 VGND VGND VPWR VPWR _0478_ sky130_fd_sc_hd__a22o_1
X_7655_ clknet_leaf_32_clk _0189_ VGND VGND VPWR VPWR memory\[19\]\[24\] sky130_fd_sc_hd__dfxtp_1
XANTENNA_10 _1271_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_32 _2621_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_21 _2032_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_65 net55 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7586_ clknet_leaf_109_clk _1145_ VGND VGND VPWR VPWR memory\[23\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_7_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_6_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_54 _2920_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6606_ _2631_ _3371_ _3372_ net567 VGND VGND VPWR VPWR _0303_ sky130_fd_sc_hd__a22o_1
XANTENNA_43 _2777_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3818_ _1508_ VGND VGND VPWR VPWR _0006_ sky130_fd_sc_hd__clkbuf_1
XANTENNA_87 net99 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_76 net69 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_98 _1819_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4798_ net12 net11 VGND VGND VPWR VPWR _2440_ sky130_fd_sc_hd__nor2_2
XFILLER_0_7_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6537_ _2855_ _3326_ VGND VGND VPWR VPWR _3337_ sky130_fd_sc_hd__and2_1
XFILLER_0_104_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3749_ _1390_ _1438_ _1440_ _1442_ _1403_ VGND VGND VPWR VPWR _1443_ sky130_fd_sc_hd__a221o_1
XFILLER_0_30_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6468_ net966 _3291_ _3294_ _3297_ VGND VGND VPWR VPWR _0240_ sky130_fd_sc_hd__a31o_1
X_5419_ _2759_ VGND VGND VPWR VPWR _2762_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_11_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6399_ _2870_ _3251_ VGND VGND VPWR VPWR _3257_ sky130_fd_sc_hd__and2_1
XFILLER_0_30_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_84_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_108_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_108_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_683 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_68_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_4_9_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_9_0_clk sky130_fd_sc_hd__clkbuf_8
XTAP_618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5770_ _2644_ _2913_ _2914_ net579 VGND VGND VPWR VPWR _0918_ sky130_fd_sc_hd__a22o_1
XFILLER_0_29_534 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4721_ _1964_ _2367_ _1968_ VGND VGND VPWR VPWR _2368_ sky130_fd_sc_hd__o21a_1
XTAP_1390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4652_ _2302_ VGND VGND VPWR VPWR _0047_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_4_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_7440_ clknet_leaf_102_clk _0999_ VGND VGND VPWR VPWR memory\[1\]\[1\] sky130_fd_sc_hd__dfxtp_1
Xinput30 data_in[22] VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__clkbuf_2
X_3603_ memory\[0\]\[5\] memory\[1\]\[5\] memory\[2\]\[5\] memory\[3\]\[5\] _1240_
+ _1241_ VGND VGND VPWR VPWR _1304_ sky130_fd_sc_hd__mux4_1
X_4583_ _1964_ _2236_ _1968_ VGND VGND VPWR VPWR _2237_ sky130_fd_sc_hd__o21a_1
X_7371_ clknet_leaf_26_clk _0930_ VGND VGND VPWR VPWR memory\[18\]\[28\] sky130_fd_sc_hd__dfxtp_1
Xinput41 data_in[3] VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_4_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold803 memory\[18\]\[1\] VGND VGND VPWR VPWR net1012 sky130_fd_sc_hd__dlygate4sd3_1
X_6322_ _2451_ _3225_ VGND VGND VPWR VPWR _3227_ sky130_fd_sc_hd__nor2_4
Xhold836 memory\[28\]\[8\] VGND VGND VPWR VPWR net1045 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_3_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold825 memory\[16\]\[12\] VGND VGND VPWR VPWR net1034 sky130_fd_sc_hd__dlygate4sd3_1
X_3534_ _1158_ VGND VGND VPWR VPWR _1238_ sky130_fd_sc_hd__buf_6
Xhold814 memory\[24\]\[17\] VGND VGND VPWR VPWR net1023 sky130_fd_sc_hd__dlygate4sd3_1
Xhold858 memory\[5\]\[26\] VGND VGND VPWR VPWR net1067 sky130_fd_sc_hd__dlygate4sd3_1
X_6253_ _2840_ _3184_ VGND VGND VPWR VPWR _3188_ sky130_fd_sc_hd__and2_1
X_3465_ _1170_ VGND VGND VPWR VPWR _1171_ sky130_fd_sc_hd__clkbuf_8
Xhold847 memory\[11\]\[6\] VGND VGND VPWR VPWR net1056 sky130_fd_sc_hd__dlygate4sd3_1
Xhold869 memory\[11\]\[16\] VGND VGND VPWR VPWR net1078 sky130_fd_sc_hd__dlygate4sd3_1
X_5204_ _2684_ VGND VGND VPWR VPWR _2685_ sky130_fd_sc_hd__clkbuf_4
X_6184_ _2847_ _3140_ VGND VGND VPWR VPWR _3148_ sky130_fd_sc_hd__and2_1
XFILLER_0_35_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5135_ net19 VGND VGND VPWR VPWR _2636_ sky130_fd_sc_hd__buf_4
X_5066_ net1151 _2585_ _2586_ VGND VGND VPWR VPWR _2589_ sky130_fd_sc_hd__and3_1
X_4017_ memory\[24\]\[26\] memory\[25\]\[26\] memory\[26\]\[26\] memory\[27\]\[26\]
+ _1551_ _1552_ VGND VGND VPWR VPWR _1697_ sky130_fd_sc_hd__mux4_1
XFILLER_0_109_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5968_ _3009_ VGND VGND VPWR VPWR _3023_ sky130_fd_sc_hd__buf_2
X_4919_ _2484_ _2499_ _2500_ net1015 VGND VGND VPWR VPWR _0512_ sky130_fd_sc_hd__a22o_1
X_7707_ clknet_leaf_87_clk _0241_ VGND VGND VPWR VPWR memory\[5\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_90_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5899_ _2865_ _2978_ VGND VGND VPWR VPWR _2983_ sky130_fd_sc_hd__and2_1
XFILLER_0_47_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_117_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7638_ clknet_leaf_112_clk _0172_ VGND VGND VPWR VPWR memory\[19\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_35_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7569_ clknet_leaf_115_clk _1128_ VGND VGND VPWR VPWR memory\[23\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_31_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_120_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_93_470 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_26_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_95_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_119_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6940_ clknet_leaf_68_clk _0531_ VGND VGND VPWR VPWR memory\[10\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_88_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6871_ clknet_leaf_9_clk _0462_ VGND VGND VPWR VPWR memory\[28\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_76_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5822_ memory\[25\]\[13\] _2930_ _2934_ VGND VGND VPWR VPWR _2938_ sky130_fd_sc_hd__and3_1
XFILLER_0_91_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5753_ _2611_ _2910_ _2912_ net1012 VGND VGND VPWR VPWR _0903_ sky130_fd_sc_hd__a22o_1
X_4704_ _2097_ _2347_ _2349_ _2351_ _2249_ VGND VGND VPWR VPWR _2352_ sky130_fd_sc_hd__a221o_1
XFILLER_0_72_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_114_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_17_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5684_ net774 _2844_ _2857_ _2864_ VGND VGND VPWR VPWR _0882_ sky130_fd_sc_hd__a31o_1
XFILLER_0_114_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4635_ memory\[24\]\[23\] memory\[25\]\[23\] memory\[26\]\[23\] memory\[27\]\[23\]
+ _1872_ _1873_ VGND VGND VPWR VPWR _2286_ sky130_fd_sc_hd__mux4_1
X_7423_ clknet_leaf_68_clk net129 VGND VGND VPWR VPWR memory\[0\]\[16\] sky130_fd_sc_hd__dfxtp_1
Xhold611 memory\[8\]\[29\] VGND VGND VPWR VPWR net820 sky130_fd_sc_hd__dlygate4sd3_1
Xhold600 memory\[20\]\[21\] VGND VGND VPWR VPWR net809 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_8_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_4_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7354_ clknet_leaf_92_clk _0913_ VGND VGND VPWR VPWR memory\[18\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_13_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4566_ memory\[28\]\[19\] memory\[29\]\[19\] memory\[30\]\[19\] memory\[31\]\[19\]
+ _2092_ _2093_ VGND VGND VPWR VPWR _2221_ sky130_fd_sc_hd__mux4_1
Xhold633 memory\[18\]\[25\] VGND VGND VPWR VPWR net842 sky130_fd_sc_hd__dlygate4sd3_1
X_6305_ _2893_ _3210_ VGND VGND VPWR VPWR _3217_ sky130_fd_sc_hd__and2_1
XFILLER_0_102_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3517_ _1193_ _1221_ _1197_ VGND VGND VPWR VPWR _1222_ sky130_fd_sc_hd__o21a_1
XFILLER_0_69_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold622 memory\[4\]\[19\] VGND VGND VPWR VPWR net831 sky130_fd_sc_hd__dlygate4sd3_1
Xhold644 memory\[24\]\[15\] VGND VGND VPWR VPWR net853 sky130_fd_sc_hd__dlygate4sd3_1
Xhold655 memory\[2\]\[22\] VGND VGND VPWR VPWR net864 sky130_fd_sc_hd__dlygate4sd3_1
X_7285_ clknet_leaf_43_clk _0844_ VGND VGND VPWR VPWR memory\[8\]\[6\] sky130_fd_sc_hd__dfxtp_1
Xhold677 memory\[11\]\[3\] VGND VGND VPWR VPWR net886 sky130_fd_sc_hd__dlygate4sd3_1
Xhold688 memory\[5\]\[7\] VGND VGND VPWR VPWR net897 sky130_fd_sc_hd__dlygate4sd3_1
Xhold666 memory\[27\]\[7\] VGND VGND VPWR VPWR net875 sky130_fd_sc_hd__dlygate4sd3_1
X_4497_ memory\[0\]\[15\] memory\[1\]\[15\] memory\[2\]\[15\] memory\[3\]\[15\] _2017_
+ _2018_ VGND VGND VPWR VPWR _2156_ sky130_fd_sc_hd__mux4_1
X_3448_ _1153_ VGND VGND VPWR VPWR _1154_ sky130_fd_sc_hd__inv_6
X_6236_ _2899_ _3167_ VGND VGND VPWR VPWR _3177_ sky130_fd_sc_hd__and2_1
Xhold699 memory\[5\]\[17\] VGND VGND VPWR VPWR net908 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_971 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_960 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6167_ net642 _3130_ _3094_ _3136_ VGND VGND VPWR VPWR _1125_ sky130_fd_sc_hd__a31o_1
XFILLER_0_85_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_993 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_982 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5118_ _2623_ _2609_ VGND VGND VPWR VPWR _2624_ sky130_fd_sc_hd__and2_1
X_6098_ net934 _3088_ _3095_ _3098_ VGND VGND VPWR VPWR _1094_ sky130_fd_sc_hd__a31o_1
X_5049_ net1141 _2572_ _2573_ VGND VGND VPWR VPWR _2579_ sky130_fd_sc_hd__and3_1
XFILLER_0_95_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_106_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_35_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_105_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f__3446_ clknet_0__3446_ VGND VGND VPWR VPWR clknet_1_1__leaf__3446_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_85_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_73_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_684 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_109_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_121_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_14_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4420_ _1876_ _2082_ _1880_ VGND VGND VPWR VPWR _2083_ sky130_fd_sc_hd__o21a_1
XFILLER_0_41_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4351_ _1799_ VGND VGND VPWR VPWR _2017_ sky130_fd_sc_hd__buf_6
XFILLER_0_10_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4282_ _1829_ _1950_ VGND VGND VPWR VPWR _1951_ sky130_fd_sc_hd__or2_1
X_7070_ clknet_leaf_83_clk _0661_ VGND VGND VPWR VPWR memory\[4\]\[15\] sky130_fd_sc_hd__dfxtp_1
XTAP_256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6021_ _2834_ _3053_ VGND VGND VPWR VPWR _3054_ sky130_fd_sc_hd__and2_1
XTAP_278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6923_ clknet_leaf_52_clk _0514_ VGND VGND VPWR VPWR memory\[15\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_64_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3997_ memory\[16\]\[25\] memory\[17\]\[25\] memory\[18\]\[25\] memory\[19\]\[25\]
+ _1547_ _1548_ VGND VGND VPWR VPWR _1678_ sky130_fd_sc_hd__mux4_1
X_6785_ _2676_ _3428_ _3430_ net1030 VGND VGND VPWR VPWR _0419_ sky130_fd_sc_hd__a22o_1
X_5805_ net1159 _2597_ _2921_ VGND VGND VPWR VPWR _2928_ sky130_fd_sc_hd__and3_1
X_5736_ net462 _2890_ _2880_ _2900_ VGND VGND VPWR VPWR _0898_ sky130_fd_sc_hd__a31o_1
XFILLER_0_57_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5667_ net976 _2844_ _2833_ _2852_ VGND VGND VPWR VPWR _0877_ sky130_fd_sc_hd__a31o_1
X_4618_ memory\[16\]\[22\] memory\[17\]\[22\] memory\[18\]\[22\] memory\[19\]\[22\]
+ _2028_ _2029_ VGND VGND VPWR VPWR _2270_ sky130_fd_sc_hd__mux4_1
X_7406_ clknet_leaf_20_clk _0965_ VGND VGND VPWR VPWR memory\[25\]\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_32_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5598_ _2640_ _2804_ VGND VGND VPWR VPWR _2809_ sky130_fd_sc_hd__and2_1
XFILLER_0_4_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7337_ clknet_leaf_56_clk _0896_ VGND VGND VPWR VPWR memory\[7\]\[26\] sky130_fd_sc_hd__dfxtp_1
Xhold441 memory\[16\]\[22\] VGND VGND VPWR VPWR net650 sky130_fd_sc_hd__dlygate4sd3_1
Xhold463 memory\[3\]\[17\] VGND VGND VPWR VPWR net672 sky130_fd_sc_hd__dlygate4sd3_1
Xhold452 memory\[29\]\[16\] VGND VGND VPWR VPWR net661 sky130_fd_sc_hd__dlygate4sd3_1
X_4549_ _2116_ _2204_ _2118_ VGND VGND VPWR VPWR _2205_ sky130_fd_sc_hd__o21a_1
Xhold430 memory\[27\]\[0\] VGND VGND VPWR VPWR net639 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold485 memory\[1\]\[26\] VGND VGND VPWR VPWR net694 sky130_fd_sc_hd__dlygate4sd3_1
Xhold496 memory\[4\]\[22\] VGND VGND VPWR VPWR net705 sky130_fd_sc_hd__dlygate4sd3_1
X_7268_ net171 _0013_ VGND VGND VPWR VPWR net95 sky130_fd_sc_hd__dfxtp_2
Xhold474 memory\[24\]\[9\] VGND VGND VPWR VPWR net683 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6219_ _2881_ _3167_ VGND VGND VPWR VPWR _3168_ sky130_fd_sc_hd__and2_1
X_7199_ clknet_leaf_67_clk _0790_ VGND VGND VPWR VPWR memory\[14\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_99_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_790 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_543 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_82_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_106_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_23_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_25_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3920_ net10 VGND VGND VPWR VPWR _1606_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_86_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3851_ memory\[8\]\[17\] memory\[9\]\[17\] memory\[10\]\[17\] memory\[11\]\[17\]
+ _1426_ _1427_ VGND VGND VPWR VPWR _1540_ sky130_fd_sc_hd__mux4_1
XFILLER_0_39_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6570_ _2888_ _3352_ VGND VGND VPWR VPWR _3356_ sky130_fd_sc_hd__and2_1
X_3782_ memory\[24\]\[14\] memory\[25\]\[14\] memory\[26\]\[14\] memory\[27\]\[14\]
+ _1353_ _1354_ VGND VGND VPWR VPWR _1474_ sky130_fd_sc_hd__mux4_1
XFILLER_0_27_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5521_ _2669_ _2781_ _2782_ net225 VGND VGND VPWR VPWR _0833_ sky130_fd_sc_hd__a22o_1
X_5545__21 clknet_1_0__leaf__2785_ VGND VGND VPWR VPWR net166 sky130_fd_sc_hd__inv_2
XFILLER_0_81_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_495 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5452_ _2456_ _2767_ _2769_ net291 VGND VGND VPWR VPWR _0777_ sky130_fd_sc_hd__a22o_1
XFILLER_0_41_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5383_ _2469_ _2752_ _2753_ net352 VGND VGND VPWR VPWR _0724_ sky130_fd_sc_hd__a22o_1
X_4403_ _2060_ _2062_ _2065_ _1850_ _2066_ VGND VGND VPWR VPWR _2067_ sky130_fd_sc_hd__a221o_1
XFILLER_0_1_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4334_ memory\[4\]\[7\] memory\[5\]\[7\] memory\[6\]\[7\] memory\[7\]\[7\] _1842_
+ _1843_ VGND VGND VPWR VPWR _2001_ sky130_fd_sc_hd__mux4_1
X_7122_ clknet_leaf_104_clk _0713_ VGND VGND VPWR VPWR memory\[3\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_7053_ clknet_leaf_41_clk _0644_ VGND VGND VPWR VPWR memory\[16\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_10_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6004_ _2895_ _3036_ VGND VGND VPWR VPWR _3043_ sky130_fd_sc_hd__and2_1
XFILLER_0_66_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4265_ _1876_ _1934_ _1880_ VGND VGND VPWR VPWR _1935_ sky130_fd_sc_hd__o21a_1
XFILLER_0_66_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4196_ _1808_ VGND VGND VPWR VPWR _1869_ sky130_fd_sc_hd__buf_4
XFILLER_0_96_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7886_ clknet_leaf_41_clk _0420_ VGND VGND VPWR VPWR memory\[13\]\[31\] sky130_fd_sc_hd__dfxtp_1
X_6906_ clknet_leaf_73_clk _0497_ VGND VGND VPWR VPWR memory\[15\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_119_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_107_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6768_ _2642_ _3432_ _3433_ net474 VGND VGND VPWR VPWR _0404_ sky130_fd_sc_hd__a22o_1
XFILLER_0_17_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5719_ _2888_ _2882_ VGND VGND VPWR VPWR _2889_ sky130_fd_sc_hd__and2_1
X_6699_ net17 _3401_ VGND VGND VPWR VPWR _3402_ sky130_fd_sc_hd__and2_1
XFILLER_0_5_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_370 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold260 memory\[12\]\[28\] VGND VGND VPWR VPWR net469 sky130_fd_sc_hd__dlygate4sd3_1
Xhold271 memory\[27\]\[20\] VGND VGND VPWR VPWR net480 sky130_fd_sc_hd__dlygate4sd3_1
Xhold293 memory\[22\]\[20\] VGND VGND VPWR VPWR net502 sky130_fd_sc_hd__dlygate4sd3_1
Xhold282 memory\[3\]\[19\] VGND VGND VPWR VPWR net491 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_99_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_100 _1863_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_122 _2886_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_133 _3181_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_111 _2462_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_144 net92 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_1742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_554 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_28_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1775 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1797 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1786 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_102_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_36_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_24_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4050_ memory\[20\]\[28\] memory\[21\]\[28\] memory\[22\]\[28\] memory\[23\]\[28\]
+ _1240_ _1241_ VGND VGND VPWR VPWR _1728_ sky130_fd_sc_hd__mux4_1
Xinput6 data_addr2[0] VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__buf_2
X_4952_ net1120 _2516_ _2513_ VGND VGND VPWR VPWR _2522_ sky130_fd_sc_hd__and3_1
X_7740_ clknet_leaf_95_clk _0274_ VGND VGND VPWR VPWR memory\[22\]\[13\] sky130_fd_sc_hd__dfxtp_1
X_3903_ memory\[24\]\[20\] memory\[25\]\[20\] memory\[26\]\[20\] memory\[27\]\[20\]
+ _1551_ _1552_ VGND VGND VPWR VPWR _1589_ sky130_fd_sc_hd__mux4_1
X_4883_ _2489_ _2490_ _2491_ VGND VGND VPWR VPWR _2492_ sky130_fd_sc_hd__and3_1
XFILLER_0_74_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7671_ clknet_leaf_111_clk _0205_ VGND VGND VPWR VPWR memory\[21\]\[8\] sky130_fd_sc_hd__dfxtp_1
X_6622_ _2663_ _3373_ _3374_ net456 VGND VGND VPWR VPWR _0317_ sky130_fd_sc_hd__a22o_1
X_3834_ _1483_ _1523_ VGND VGND VPWR VPWR _1524_ sky130_fd_sc_hd__or2_1
XFILLER_0_104_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3765_ memory\[28\]\[13\] memory\[29\]\[13\] memory\[30\]\[13\] memory\[31\]\[13\]
+ _1398_ _1399_ VGND VGND VPWR VPWR _1458_ sky130_fd_sc_hd__mux4_1
X_6553_ _2508_ VGND VGND VPWR VPWR _3346_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_42_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3696_ memory\[16\]\[10\] memory\[17\]\[10\] memory\[18\]\[10\] memory\[19\]\[10\]
+ _1349_ _1350_ VGND VGND VPWR VPWR _1392_ sky130_fd_sc_hd__mux4_1
XFILLER_0_15_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5504_ _2636_ _2779_ _2780_ net1029 VGND VGND VPWR VPWR _0818_ sky130_fd_sc_hd__a22o_1
X_6484_ _2878_ _3295_ VGND VGND VPWR VPWR _3306_ sky130_fd_sc_hd__and2_1
X_5435_ _2480_ _2763_ _2764_ net299 VGND VGND VPWR VPWR _0765_ sky130_fd_sc_hd__a22o_1
XFILLER_0_65_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_2_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_77_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5366_ _2750_ VGND VGND VPWR VPWR _2751_ sky130_fd_sc_hd__clkbuf_4
X_5297_ _2659_ _2721_ VGND VGND VPWR VPWR _2724_ sky130_fd_sc_hd__and2_1
X_7105_ clknet_leaf_78_clk _0696_ VGND VGND VPWR VPWR memory\[29\]\[18\] sky130_fd_sc_hd__dfxtp_1
X_4317_ memory\[0\]\[6\] memory\[1\]\[6\] memory\[2\]\[6\] memory\[3\]\[6\] _1845_
+ _1846_ VGND VGND VPWR VPWR _1985_ sky130_fd_sc_hd__mux4_1
X_4248_ _1862_ _1912_ _1916_ _1918_ _1851_ VGND VGND VPWR VPWR _1919_ sky130_fd_sc_hd__a221o_1
X_7036_ clknet_leaf_90_clk _0627_ VGND VGND VPWR VPWR memory\[16\]\[13\] sky130_fd_sc_hd__dfxtp_1
X_4179_ _1828_ _1852_ VGND VGND VPWR VPWR _1853_ sky130_fd_sc_hd__and2_1
XFILLER_0_77_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7938_ net201 _0042_ VGND VGND VPWR VPWR net60 sky130_fd_sc_hd__dfxtp_2
XTAP_1038 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1027 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1016 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1005 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1049 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7869_ clknet_leaf_67_clk _0403_ VGND VGND VPWR VPWR memory\[13\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_107_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_376 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_98_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3550_ _1153_ VGND VGND VPWR VPWR _1254_ sky130_fd_sc_hd__buf_4
XFILLER_0_3_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_122_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5220_ _2468_ _2686_ _2687_ net660 VGND VGND VPWR VPWR _0627_ sky130_fd_sc_hd__a22o_1
X_3481_ net6 VGND VGND VPWR VPWR _1187_ sky130_fd_sc_hd__buf_6
XFILLER_0_122_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5151_ _2646_ _2632_ VGND VGND VPWR VPWR _2647_ sky130_fd_sc_hd__and2_1
X_4102_ _1769_ _1777_ VGND VGND VPWR VPWR _1778_ sky130_fd_sc_hd__and2_1
X_5082_ _2529_ VGND VGND VPWR VPWR _2597_ sky130_fd_sc_hd__clkbuf_4
X_4033_ memory\[16\]\[27\] memory\[17\]\[27\] memory\[18\]\[27\] memory\[19\]\[27\]
+ _1547_ _1548_ VGND VGND VPWR VPWR _1712_ sky130_fd_sc_hd__mux4_1
XFILLER_0_2_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7723_ clknet_leaf_47_clk _0257_ VGND VGND VPWR VPWR memory\[5\]\[28\] sky130_fd_sc_hd__dfxtp_1
X_5984_ net1023 _3021_ _3022_ _3031_ VGND VGND VPWR VPWR _1047_ sky130_fd_sc_hd__a31o_1
X_4935_ _2510_ _2501_ _2511_ VGND VGND VPWR VPWR _2512_ sky130_fd_sc_hd__nand3_2
XFILLER_0_74_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_59_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7654_ clknet_leaf_38_clk _0188_ VGND VGND VPWR VPWR memory\[19\]\[23\] sky130_fd_sc_hd__dfxtp_1
X_4866_ net33 VGND VGND VPWR VPWR _2482_ sky130_fd_sc_hd__buf_4
XANTENNA_11 _1633_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_516 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XANTENNA_22 _2033_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_55 _3005_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_66 net57 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7585_ clknet_leaf_107_clk _1144_ VGND VGND VPWR VPWR memory\[23\]\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_27_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_33 _2625_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_44 _2842_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4797_ net16 VGND VGND VPWR VPWR _2439_ sky130_fd_sc_hd__clkbuf_8
X_3817_ _1499_ _1507_ VGND VGND VPWR VPWR _1508_ sky130_fd_sc_hd__and2_1
X_6605_ _3369_ VGND VGND VPWR VPWR _3372_ sky130_fd_sc_hd__clkbuf_4
XANTENNA_77 net70 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_99 _1819_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6536_ net733 _3333_ _3324_ _3336_ VGND VGND VPWR VPWR _0269_ sky130_fd_sc_hd__a31o_1
XFILLER_0_6_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_88 net100 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3748_ _1397_ _1441_ _1401_ VGND VGND VPWR VPWR _1442_ sky130_fd_sc_hd__o21a_1
XFILLER_0_6_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_30_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_113_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_112_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_100_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3679_ memory\[24\]\[9\] memory\[25\]\[9\] memory\[26\]\[9\] memory\[27\]\[9\] _1353_
+ _1354_ VGND VGND VPWR VPWR _1376_ sky130_fd_sc_hd__mux4_1
X_6467_ _2861_ _3295_ VGND VGND VPWR VPWR _3297_ sky130_fd_sc_hd__and2_1
X_5418_ _2757_ VGND VGND VPWR VPWR _2761_ sky130_fd_sc_hd__clkbuf_4
X_6398_ net636 _3249_ _3250_ _3256_ VGND VGND VPWR VPWR _0211_ sky130_fd_sc_hd__a31o_1
X_5349_ _2475_ _2744_ _2745_ net243 VGND VGND VPWR VPWR _0698_ sky130_fd_sc_hd__a22o_1
X_7019_ clknet_leaf_27_clk _0610_ VGND VGND VPWR VPWR memory\[26\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_78_671 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_38_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_50_clk clknet_4_14_0_clk VGND VGND VPWR VPWR clknet_leaf_50_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_53_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_110_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4720_ memory\[12\]\[27\] memory\[13\]\[27\] memory\[14\]\[27\] memory\[15\]\[27\]
+ _1965_ _1966_ VGND VGND VPWR VPWR _2367_ sky130_fd_sc_hd__mux4_1
XTAP_1391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_41_clk clknet_4_9_0_clk VGND VGND VPWR VPWR clknet_leaf_41_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_29_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4651_ _2293_ _2301_ VGND VGND VPWR VPWR _2302_ sky130_fd_sc_hd__and2_1
XFILLER_0_99_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_71_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput20 data_in[13] VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__buf_2
Xinput31 data_in[23] VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__buf_2
XFILLER_0_4_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3602_ memory\[4\]\[5\] memory\[5\]\[5\] memory\[6\]\[5\] memory\[7\]\[5\] _1237_
+ _1238_ VGND VGND VPWR VPWR _1303_ sky130_fd_sc_hd__mux4_1
XFILLER_0_114_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7370_ clknet_leaf_32_clk _0929_ VGND VGND VPWR VPWR memory\[18\]\[27\] sky130_fd_sc_hd__dfxtp_1
X_4582_ memory\[28\]\[20\] memory\[29\]\[20\] memory\[30\]\[20\] memory\[31\]\[20\]
+ _1960_ _1961_ VGND VGND VPWR VPWR _2236_ sky130_fd_sc_hd__mux4_1
XFILLER_0_4_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xinput42 data_in[4] VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__clkbuf_2
Xhold815 memory\[8\]\[11\] VGND VGND VPWR VPWR net1024 sky130_fd_sc_hd__dlygate4sd3_1
Xhold837 memory\[20\]\[7\] VGND VGND VPWR VPWR net1046 sky130_fd_sc_hd__dlygate4sd3_1
Xhold804 memory\[7\]\[4\] VGND VGND VPWR VPWR net1013 sky130_fd_sc_hd__dlygate4sd3_1
Xhold826 memory\[26\]\[7\] VGND VGND VPWR VPWR net1035 sky130_fd_sc_hd__dlygate4sd3_1
X_6321_ _3225_ VGND VGND VPWR VPWR _3226_ sky130_fd_sc_hd__clkbuf_4
X_3533_ _1156_ VGND VGND VPWR VPWR _1237_ sky130_fd_sc_hd__buf_8
Xhold848 memory\[29\]\[30\] VGND VGND VPWR VPWR net1057 sky130_fd_sc_hd__dlygate4sd3_1
Xhold859 memory\[18\]\[6\] VGND VGND VPWR VPWR net1068 sky130_fd_sc_hd__dlygate4sd3_1
X_3464_ net6 VGND VGND VPWR VPWR _1170_ sky130_fd_sc_hd__buf_8
X_6252_ _3145_ VGND VGND VPWR VPWR _3187_ sky130_fd_sc_hd__buf_4
XFILLER_0_110_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5203_ _2451_ _2682_ VGND VGND VPWR VPWR _2684_ sky130_fd_sc_hd__nor2_4
XFILLER_0_58_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6183_ net901 _3146_ _3138_ _3147_ VGND VGND VPWR VPWR _1130_ sky130_fd_sc_hd__a31o_1
X_5134_ net1073 _2629_ _2630_ _2635_ VGND VGND VPWR VPWR _0593_ sky130_fd_sc_hd__a31o_1
X_5065_ _2478_ _2584_ _2588_ VGND VGND VPWR VPWR _0571_ sky130_fd_sc_hd__a21o_1
XFILLER_0_74_51 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4016_ _1694_ _1695_ _1176_ VGND VGND VPWR VPWR _1696_ sky130_fd_sc_hd__mux2_1
XFILLER_0_28_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_59_192 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5967_ _3007_ VGND VGND VPWR VPWR _3022_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_47_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4918_ _2483_ _2499_ _2500_ net342 VGND VGND VPWR VPWR _0511_ sky130_fd_sc_hd__a22o_1
Xclkbuf_leaf_32_clk clknet_4_10_0_clk VGND VGND VPWR VPWR clknet_leaf_32_clk sky130_fd_sc_hd__clkbuf_16
X_7706_ clknet_leaf_87_clk _0240_ VGND VGND VPWR VPWR memory\[5\]\[11\] sky130_fd_sc_hd__dfxtp_1
X_7637_ clknet_leaf_114_clk _0171_ VGND VGND VPWR VPWR memory\[19\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_47_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5898_ net477 _2981_ _2977_ _2982_ VGND VGND VPWR VPWR _1010_ sky130_fd_sc_hd__a31o_1
X_4849_ _2472_ _2464_ _2465_ net645 VGND VGND VPWR VPWR _0470_ sky130_fd_sc_hd__a22o_1
X_7568_ clknet_leaf_115_clk _1127_ VGND VGND VPWR VPWR memory\[23\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_7499_ clknet_leaf_28_clk _1058_ VGND VGND VPWR VPWR memory\[24\]\[28\] sky130_fd_sc_hd__dfxtp_1
X_6519_ net464 _3317_ _3324_ _3327_ VGND VGND VPWR VPWR _0261_ sky130_fd_sc_hd__a31o_1
Xclkbuf_leaf_99_clk clknet_4_6_0_clk VGND VGND VPWR VPWR clknet_leaf_99_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_100_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_97_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_109_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_23_clk clknet_4_8_0_clk VGND VGND VPWR VPWR clknet_leaf_23_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_93_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_110_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_80_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6870_ clknet_leaf_8_clk _0461_ VGND VGND VPWR VPWR memory\[28\]\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_49_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5821_ _2467_ _2933_ _2937_ VGND VGND VPWR VPWR _0946_ sky130_fd_sc_hd__a21o_1
XFILLER_0_17_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5752_ _2607_ _2910_ _2912_ net738 VGND VGND VPWR VPWR _0902_ sky130_fd_sc_hd__a22o_1
X_4703_ _2104_ _2350_ _2106_ VGND VGND VPWR VPWR _2351_ sky130_fd_sc_hd__o21a_1
Xclkbuf_leaf_14_clk clknet_4_9_0_clk VGND VGND VPWR VPWR clknet_leaf_14_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_56_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5683_ _2863_ _2859_ VGND VGND VPWR VPWR _2864_ sky130_fd_sc_hd__and2_1
X_4634_ _2285_ VGND VGND VPWR VPWR _0046_ sky130_fd_sc_hd__buf_1
XFILLER_0_4_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7422_ clknet_leaf_85_clk net130 VGND VGND VPWR VPWR memory\[0\]\[15\] sky130_fd_sc_hd__dfxtp_1
Xhold612 memory\[24\]\[23\] VGND VGND VPWR VPWR net821 sky130_fd_sc_hd__dlygate4sd3_1
Xhold601 memory\[1\]\[29\] VGND VGND VPWR VPWR net810 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_8_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_7353_ clknet_leaf_93_clk _0912_ VGND VGND VPWR VPWR memory\[18\]\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_4_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4565_ _2113_ _2219_ VGND VGND VPWR VPWR _2220_ sky130_fd_sc_hd__or2_1
X_6304_ net813 _3213_ _3209_ _3216_ VGND VGND VPWR VPWR _0157_ sky130_fd_sc_hd__a31o_1
X_3516_ memory\[12\]\[1\] memory\[13\]\[1\] memory\[14\]\[1\] memory\[15\]\[1\] _1194_
+ _1195_ VGND VGND VPWR VPWR _1221_ sky130_fd_sc_hd__mux4_2
Xhold623 memory\[12\]\[3\] VGND VGND VPWR VPWR net832 sky130_fd_sc_hd__dlygate4sd3_1
Xhold645 memory\[8\]\[15\] VGND VGND VPWR VPWR net854 sky130_fd_sc_hd__dlygate4sd3_1
Xhold634 memory\[4\]\[14\] VGND VGND VPWR VPWR net843 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold656 memory\[9\]\[22\] VGND VGND VPWR VPWR net865 sky130_fd_sc_hd__dlygate4sd3_1
Xhold667 memory\[4\]\[29\] VGND VGND VPWR VPWR net876 sky130_fd_sc_hd__dlygate4sd3_1
Xhold678 memory\[15\]\[1\] VGND VGND VPWR VPWR net887 sky130_fd_sc_hd__dlygate4sd3_1
X_7284_ clknet_leaf_8_clk _0843_ VGND VGND VPWR VPWR memory\[8\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_4496_ memory\[4\]\[15\] memory\[5\]\[15\] memory\[6\]\[15\] memory\[7\]\[15\] _2014_
+ _2015_ VGND VGND VPWR VPWR _2155_ sky130_fd_sc_hd__mux4_1
X_6235_ net1040 _3172_ _3166_ _3176_ VGND VGND VPWR VPWR _0128_ sky130_fd_sc_hd__a31o_1
X_3447_ net9 VGND VGND VPWR VPWR _1153_ sky130_fd_sc_hd__buf_6
XFILLER_0_0_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold689 memory\[28\]\[10\] VGND VGND VPWR VPWR net898 sky130_fd_sc_hd__dlygate4sd3_1
X_6166_ _2905_ _3096_ VGND VGND VPWR VPWR _3136_ sky130_fd_sc_hd__and2_1
XTAP_950 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_961 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5117_ net45 VGND VGND VPWR VPWR _2623_ sky130_fd_sc_hd__buf_4
XTAP_994 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_983 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_972 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6097_ _2834_ _3097_ VGND VGND VPWR VPWR _3098_ sky130_fd_sc_hd__and2_1
XFILLER_0_109_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5048_ _2469_ _2571_ _2578_ VGND VGND VPWR VPWR _0564_ sky130_fd_sc_hd__a21o_1
XFILLER_0_94_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_4_8_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_8_0_clk sky130_fd_sc_hd__clkbuf_8
X_6999_ clknet_leaf_2_clk _0590_ VGND VGND VPWR VPWR memory\[26\]\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_48_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_106_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_90_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_215 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_43_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_105_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f__3445_ clknet_0__3445_ VGND VGND VPWR VPWR clknet_1_1__leaf__3445_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_66_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_121_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_54_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4350_ memory\[4\]\[8\] memory\[5\]\[8\] memory\[6\]\[8\] memory\[7\]\[8\] _2014_
+ _2015_ VGND VGND VPWR VPWR _2016_ sky130_fd_sc_hd__mux4_1
XFILLER_0_10_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4281_ memory\[8\]\[5\] memory\[9\]\[5\] memory\[10\]\[5\] memory\[11\]\[5\] _1948_
+ _1949_ VGND VGND VPWR VPWR _1950_ sky130_fd_sc_hd__mux4_1
X_6020_ _3052_ VGND VGND VPWR VPWR _3053_ sky130_fd_sc_hd__clkbuf_4
XTAP_246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_3_clk clknet_4_2_0_clk VGND VGND VPWR VPWR clknet_leaf_3_clk sky130_fd_sc_hd__clkbuf_16
XTAP_279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6922_ clknet_leaf_52_clk _0513_ VGND VGND VPWR VPWR memory\[15\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_49_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5804_ _2458_ _2919_ _2927_ VGND VGND VPWR VPWR _0939_ sky130_fd_sc_hd__a21o_1
X_6784_ _2673_ _3434_ _3435_ net834 VGND VGND VPWR VPWR _0418_ sky130_fd_sc_hd__a22o_1
XFILLER_0_119_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3996_ memory\[20\]\[25\] memory\[21\]\[25\] memory\[22\]\[25\] memory\[23\]\[25\]
+ _1509_ _1510_ VGND VGND VPWR VPWR _1677_ sky130_fd_sc_hd__mux4_1
XFILLER_0_92_728 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5735_ _2899_ _2882_ VGND VGND VPWR VPWR _2900_ sky130_fd_sc_hd__and2_1
XFILLER_0_91_249 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_29_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_95_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_60_603 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5666_ _2851_ _2836_ VGND VGND VPWR VPWR _2852_ sky130_fd_sc_hd__and2_1
XFILLER_0_32_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4617_ memory\[20\]\[22\] memory\[21\]\[22\] memory\[22\]\[22\] memory\[23\]\[22\]
+ _1866_ _1867_ VGND VGND VPWR VPWR _2269_ sky130_fd_sc_hd__mux4_2
X_7405_ clknet_leaf_17_clk _0964_ VGND VGND VPWR VPWR memory\[25\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_72_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_102_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5597_ net910 _2798_ _2803_ _2808_ VGND VGND VPWR VPWR _0851_ sky130_fd_sc_hd__a31o_1
XFILLER_0_60_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold420 memory\[19\]\[3\] VGND VGND VPWR VPWR net629 sky130_fd_sc_hd__dlygate4sd3_1
Xhold431 memory\[26\]\[21\] VGND VGND VPWR VPWR net640 sky130_fd_sc_hd__dlygate4sd3_1
Xhold453 memory\[18\]\[24\] VGND VGND VPWR VPWR net662 sky130_fd_sc_hd__dlygate4sd3_1
X_7336_ clknet_leaf_72_clk _0895_ VGND VGND VPWR VPWR memory\[7\]\[25\] sky130_fd_sc_hd__dfxtp_1
Xhold442 memory\[19\]\[9\] VGND VGND VPWR VPWR net651 sky130_fd_sc_hd__dlygate4sd3_1
X_4548_ memory\[28\]\[18\] memory\[29\]\[18\] memory\[30\]\[18\] memory\[31\]\[18\]
+ _2092_ _2093_ VGND VGND VPWR VPWR _2204_ sky130_fd_sc_hd__mux4_1
XFILLER_0_40_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold464 memory\[12\]\[31\] VGND VGND VPWR VPWR net673 sky130_fd_sc_hd__dlygate4sd3_1
Xhold475 memory\[24\]\[31\] VGND VGND VPWR VPWR net684 sky130_fd_sc_hd__dlygate4sd3_1
X_7267_ net170 _0012_ VGND VGND VPWR VPWR net94 sky130_fd_sc_hd__dfxtp_1
X_4479_ memory\[0\]\[14\] memory\[1\]\[14\] memory\[2\]\[14\] memory\[3\]\[14\] _2017_
+ _2018_ VGND VGND VPWR VPWR _2139_ sky130_fd_sc_hd__mux4_1
Xhold486 memory\[18\]\[7\] VGND VGND VPWR VPWR net695 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_110_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold497 memory\[7\]\[22\] VGND VGND VPWR VPWR net706 sky130_fd_sc_hd__dlygate4sd3_1
X_6218_ _3139_ VGND VGND VPWR VPWR _3167_ sky130_fd_sc_hd__buf_2
X_7198_ clknet_leaf_69_clk _0789_ VGND VGND VPWR VPWR memory\[14\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_99_305 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6149_ _2888_ _3123_ VGND VGND VPWR VPWR _3127_ sky130_fd_sc_hd__and2_1
XTAP_780 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_791 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_482 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_90_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_92_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3850_ _1537_ _1538_ _1521_ VGND VGND VPWR VPWR _1539_ sky130_fd_sc_hd__mux2_1
XFILLER_0_58_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3781_ _1470_ _1471_ _1472_ VGND VGND VPWR VPWR _1473_ sky130_fd_sc_hd__mux2_1
X_5520_ _2667_ _2781_ _2782_ net310 VGND VGND VPWR VPWR _0832_ sky130_fd_sc_hd__a22o_1
XFILLER_0_109_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5451_ _2455_ _2767_ _2769_ net408 VGND VGND VPWR VPWR _0776_ sky130_fd_sc_hd__a22o_1
X_4402_ net5 VGND VGND VPWR VPWR _2066_ sky130_fd_sc_hd__clkbuf_4
X_5382_ _2468_ _2752_ _2753_ net665 VGND VGND VPWR VPWR _0723_ sky130_fd_sc_hd__a22o_1
X_4333_ _1836_ _1999_ _1840_ VGND VGND VPWR VPWR _2000_ sky130_fd_sc_hd__o21a_1
X_7121_ clknet_leaf_105_clk _0712_ VGND VGND VPWR VPWR memory\[3\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_7052_ clknet_leaf_33_clk _0643_ VGND VGND VPWR VPWR memory\[16\]\[29\] sky130_fd_sc_hd__dfxtp_1
X_4264_ memory\[12\]\[4\] memory\[13\]\[4\] memory\[14\]\[4\] memory\[15\]\[4\] _1877_
+ _1878_ VGND VGND VPWR VPWR _1934_ sky130_fd_sc_hd__mux4_1
X_6003_ net656 _3034_ _3035_ _3042_ VGND VGND VPWR VPWR _1055_ sky130_fd_sc_hd__a31o_1
XFILLER_0_5_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4195_ memory\[0\]\[1\] memory\[1\]\[1\] memory\[2\]\[1\] memory\[3\]\[1\] _1866_
+ _1867_ VGND VGND VPWR VPWR _1868_ sky130_fd_sc_hd__mux4_1
XFILLER_0_89_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_77_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_1209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6905_ clknet_leaf_68_clk _0496_ VGND VGND VPWR VPWR memory\[15\]\[11\] sky130_fd_sc_hd__dfxtp_1
X_7885_ clknet_leaf_40_clk _0419_ VGND VGND VPWR VPWR memory\[13\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_77_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6836_ clknet_1_0__leaf__2783_ VGND VGND VPWR VPWR _3445_ sky130_fd_sc_hd__buf_1
X_6767_ _2640_ _3432_ _3433_ net558 VGND VGND VPWR VPWR _0403_ sky130_fd_sc_hd__a22o_1
X_3979_ memory\[16\]\[24\] memory\[17\]\[24\] memory\[18\]\[24\] memory\[19\]\[24\]
+ _1547_ _1548_ VGND VGND VPWR VPWR _1661_ sky130_fd_sc_hd__mux4_1
X_5718_ net31 VGND VGND VPWR VPWR _2888_ sky130_fd_sc_hd__buf_4
X_6698_ _3387_ VGND VGND VPWR VPWR _3401_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_17_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5649_ net38 VGND VGND VPWR VPWR _2840_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_33_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_103_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold261 memory\[4\]\[31\] VGND VGND VPWR VPWR net470 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold250 memory\[4\]\[10\] VGND VGND VPWR VPWR net459 sky130_fd_sc_hd__dlygate4sd3_1
X_7319_ clknet_leaf_103_clk _0878_ VGND VGND VPWR VPWR memory\[7\]\[8\] sky130_fd_sc_hd__dfxtp_1
Xhold272 memory\[31\]\[20\] VGND VGND VPWR VPWR net481 sky130_fd_sc_hd__dlygate4sd3_1
Xhold294 memory\[17\]\[1\] VGND VGND VPWR VPWR net503 sky130_fd_sc_hd__dlygate4sd3_1
Xhold283 memory\[31\]\[17\] VGND VGND VPWR VPWR net492 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_87_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_123 _2886_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_134 _3225_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_101 _1863_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_112 _2462_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_1743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_145 net104 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_1776 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1765 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_1798 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1787 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_102_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput7 data_addr2[1] VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__buf_2
XFILLER_0_36_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4951_ _2459_ _2505_ _2521_ VGND VGND VPWR VPWR _0524_ sky130_fd_sc_hd__a21o_1
XFILLER_0_52_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3902_ _1168_ VGND VGND VPWR VPWR _1588_ sky130_fd_sc_hd__buf_2
X_4882_ _2443_ _2444_ _2445_ VGND VGND VPWR VPWR _2491_ sky130_fd_sc_hd__and3b_1
X_7670_ clknet_leaf_110_clk _0204_ VGND VGND VPWR VPWR memory\[21\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_19_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6621_ _2661_ _3373_ _3374_ net286 VGND VGND VPWR VPWR _0316_ sky130_fd_sc_hd__a22o_1
X_3833_ memory\[8\]\[16\] memory\[9\]\[16\] memory\[10\]\[16\] memory\[11\]\[16\]
+ _1426_ _1427_ VGND VGND VPWR VPWR _1523_ sky130_fd_sc_hd__mux4_1
X_5528__5 clknet_1_1__leaf__2784_ VGND VGND VPWR VPWR net150 sky130_fd_sc_hd__inv_2
XFILLER_0_39_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_116_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_271 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6552_ net394 _3333_ _3338_ _3345_ VGND VGND VPWR VPWR _0276_ sky130_fd_sc_hd__a31o_1
X_3764_ _1394_ _1456_ VGND VGND VPWR VPWR _1457_ sky130_fd_sc_hd__or2_1
X_6483_ net594 _3304_ _3294_ _3305_ VGND VGND VPWR VPWR _0247_ sky130_fd_sc_hd__a31o_1
X_3695_ memory\[20\]\[10\] memory\[21\]\[10\] memory\[22\]\[10\] memory\[23\]\[10\]
+ _1312_ _1313_ VGND VGND VPWR VPWR _1391_ sky130_fd_sc_hd__mux4_1
X_5503_ _2634_ _2779_ _2780_ net292 VGND VGND VPWR VPWR _0817_ sky130_fd_sc_hd__a22o_1
XFILLER_0_42_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5434_ _2479_ _2763_ _2764_ net864 VGND VGND VPWR VPWR _0764_ sky130_fd_sc_hd__a22o_1
XFILLER_0_14_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5365_ _2451_ _2748_ VGND VGND VPWR VPWR _2750_ sky130_fd_sc_hd__nor2_4
XFILLER_0_77_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_2_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7104_ clknet_leaf_77_clk _0695_ VGND VGND VPWR VPWR memory\[29\]\[17\] sky130_fd_sc_hd__dfxtp_1
X_5296_ net697 _2717_ _2720_ _2723_ VGND VGND VPWR VPWR _0667_ sky130_fd_sc_hd__a31o_1
X_4316_ memory\[4\]\[6\] memory\[5\]\[6\] memory\[6\]\[6\] memory\[7\]\[6\] _1842_
+ _1843_ VGND VGND VPWR VPWR _1984_ sky130_fd_sc_hd__mux4_1
X_4247_ _1876_ _1917_ _1880_ VGND VGND VPWR VPWR _1918_ sky130_fd_sc_hd__o21a_1
X_7035_ clknet_leaf_90_clk _0626_ VGND VGND VPWR VPWR memory\[16\]\[12\] sky130_fd_sc_hd__dfxtp_1
X_4178_ _1835_ _1841_ _1849_ _1850_ _1851_ VGND VGND VPWR VPWR _1852_ sky130_fd_sc_hd__a221o_1
XFILLER_0_97_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_97_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7937_ net200 _0041_ VGND VGND VPWR VPWR net59 sky130_fd_sc_hd__dfxtp_2
XTAP_1028 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1017 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1006 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7868_ clknet_leaf_67_clk _0402_ VGND VGND VPWR VPWR memory\[13\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_65_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1039 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6819_ _2661_ _3443_ _3444_ net737 VGND VGND VPWR VPWR _0444_ sky130_fd_sc_hd__a22o_1
XFILLER_0_65_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7799_ clknet_leaf_22_clk _0333_ VGND VGND VPWR VPWR memory\[12\]\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_9_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_115_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_87_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_87_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_113_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_660 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3480_ _1168_ VGND VGND VPWR VPWR _1186_ sky130_fd_sc_hd__buf_4
XFILLER_0_12_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_51_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_122_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5150_ net24 VGND VGND VPWR VPWR _2646_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_47_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5081_ _2486_ _2584_ _2596_ VGND VGND VPWR VPWR _0579_ sky130_fd_sc_hd__a21o_1
X_4101_ _1771_ _1773_ _1776_ _1154_ net10 VGND VGND VPWR VPWR _1777_ sky130_fd_sc_hd__a221o_1
X_4032_ memory\[20\]\[27\] memory\[21\]\[27\] memory\[22\]\[27\] memory\[23\]\[27\]
+ _1240_ _1241_ VGND VGND VPWR VPWR _1711_ sky130_fd_sc_hd__mux4_1
XFILLER_0_63_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5983_ _2874_ _3023_ VGND VGND VPWR VPWR _3031_ sky130_fd_sc_hd__and2_1
XFILLER_0_93_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7722_ clknet_leaf_72_clk _0256_ VGND VGND VPWR VPWR memory\[5\]\[27\] sky130_fd_sc_hd__dfxtp_1
X_4934_ _2443_ _2445_ _2444_ VGND VGND VPWR VPWR _2511_ sky130_fd_sc_hd__nor3b_4
XFILLER_0_74_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_536 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4865_ _2481_ _2476_ _2477_ net340 VGND VGND VPWR VPWR _0477_ sky130_fd_sc_hd__a22o_1
X_7653_ clknet_leaf_38_clk _0187_ VGND VGND VPWR VPWR memory\[19\]\[22\] sky130_fd_sc_hd__dfxtp_1
XANTENNA_12 _1812_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_23 _2154_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_117_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4796_ _2438_ VGND VGND VPWR VPWR _0056_ sky130_fd_sc_hd__clkbuf_1
XANTENNA_45 _2861_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7584_ clknet_leaf_110_clk _1143_ VGND VGND VPWR VPWR memory\[23\]\[17\] sky130_fd_sc_hd__dfxtp_1
XANTENNA_34 _2627_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_56 _3009_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6604_ _3367_ VGND VGND VPWR VPWR _3371_ sky130_fd_sc_hd__clkbuf_4
X_3816_ _1501_ _1503_ _1506_ _1207_ _1412_ VGND VGND VPWR VPWR _1507_ sky130_fd_sc_hd__a221o_1
XANTENNA_89 net101 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6535_ _2853_ _3326_ VGND VGND VPWR VPWR _3336_ sky130_fd_sc_hd__and2_1
XANTENNA_67 net58 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_78 net71 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3747_ memory\[28\]\[12\] memory\[29\]\[12\] memory\[30\]\[12\] memory\[31\]\[12\]
+ _1398_ _1399_ VGND VGND VPWR VPWR _1441_ sky130_fd_sc_hd__mux4_1
XFILLER_0_70_572 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3678_ _1373_ _1374_ _1279_ VGND VGND VPWR VPWR _1375_ sky130_fd_sc_hd__mux2_1
X_6466_ net839 _3291_ _3294_ _3296_ VGND VGND VPWR VPWR _0239_ sky130_fd_sc_hd__a31o_1
XFILLER_0_30_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_113_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6397_ _2868_ _3251_ VGND VGND VPWR VPWR _3256_ sky130_fd_sc_hd__and2_1
X_5417_ _2462_ _2758_ _2760_ net700 VGND VGND VPWR VPWR _0751_ sky130_fd_sc_hd__a22o_1
X_5348_ _2740_ VGND VGND VPWR VPWR _2745_ sky130_fd_sc_hd__clkbuf_4
X_7018_ clknet_leaf_29_clk _0609_ VGND VGND VPWR VPWR memory\[26\]\[27\] sky130_fd_sc_hd__dfxtp_1
X_5279_ net843 _2704_ _2707_ _2713_ VGND VGND VPWR VPWR _0660_ sky130_fd_sc_hd__a31o_1
XFILLER_0_97_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_108_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_46_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_104_674 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6858__1 clknet_1_1__leaf__2783_ VGND VGND VPWR VPWR net146 sky130_fd_sc_hd__inv_2
XFILLER_0_0_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_108_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_17_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_88_458 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_56_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4650_ _2097_ _2296_ _2298_ _2300_ _2249_ VGND VGND VPWR VPWR _2301_ sky130_fd_sc_hd__a221o_1
Xinput10 data_addr2[4] VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__buf_4
XFILLER_0_116_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_83_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xinput21 data_in[14] VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__buf_2
X_3601_ _1155_ _1297_ _1299_ _1301_ _1184_ VGND VGND VPWR VPWR _1302_ sky130_fd_sc_hd__a221o_1
Xinput32 data_in[24] VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__buf_1
X_4581_ _1959_ _2234_ VGND VGND VPWR VPWR _2235_ sky130_fd_sc_hd__or2_1
X_6320_ _3224_ VGND VGND VPWR VPWR _3225_ sky130_fd_sc_hd__buf_4
XFILLER_0_3_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput43 data_in[5] VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_52_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold827 memory\[17\]\[25\] VGND VGND VPWR VPWR net1036 sky130_fd_sc_hd__dlygate4sd3_1
Xhold816 memory\[8\]\[18\] VGND VGND VPWR VPWR net1025 sky130_fd_sc_hd__dlygate4sd3_1
Xhold805 memory\[21\]\[28\] VGND VGND VPWR VPWR net1014 sky130_fd_sc_hd__dlygate4sd3_1
X_3532_ _1154_ VGND VGND VPWR VPWR _1236_ sky130_fd_sc_hd__buf_4
XFILLER_0_12_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_52_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_110_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold838 memory\[5\]\[2\] VGND VGND VPWR VPWR net1047 sky130_fd_sc_hd__dlygate4sd3_1
Xhold849 memory\[20\]\[9\] VGND VGND VPWR VPWR net1058 sky130_fd_sc_hd__dlygate4sd3_1
X_6251_ net249 _3172_ _3182_ _3186_ VGND VGND VPWR VPWR _0134_ sky130_fd_sc_hd__a31o_1
X_3463_ _1168_ VGND VGND VPWR VPWR _1169_ sky130_fd_sc_hd__buf_2
X_6182_ _2845_ _3140_ VGND VGND VPWR VPWR _3147_ sky130_fd_sc_hd__and2_1
X_5202_ _2682_ VGND VGND VPWR VPWR _2683_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_110_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5133_ _2634_ _2632_ VGND VGND VPWR VPWR _2635_ sky130_fd_sc_hd__and2_1
X_5064_ net1170 _2585_ _2586_ VGND VGND VPWR VPWR _2588_ sky130_fd_sc_hd__and3_1
X_4015_ memory\[16\]\[26\] memory\[17\]\[26\] memory\[18\]\[26\] memory\[19\]\[26\]
+ _1547_ _1548_ VGND VGND VPWR VPWR _1695_ sky130_fd_sc_hd__mux4_1
XFILLER_0_74_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5966_ _3005_ VGND VGND VPWR VPWR _3021_ sky130_fd_sc_hd__clkbuf_4
X_4917_ _2482_ _2499_ _2500_ net347 VGND VGND VPWR VPWR _0510_ sky130_fd_sc_hd__a22o_1
XFILLER_0_74_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7705_ clknet_leaf_86_clk _0239_ VGND VGND VPWR VPWR memory\[5\]\[10\] sky130_fd_sc_hd__dfxtp_1
X_5897_ _2863_ _2978_ VGND VGND VPWR VPWR _2982_ sky130_fd_sc_hd__and2_1
X_4848_ net24 VGND VGND VPWR VPWR _2472_ sky130_fd_sc_hd__buf_4
XFILLER_0_74_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7636_ clknet_leaf_116_clk _0170_ VGND VGND VPWR VPWR memory\[19\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_105_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_90_678 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4779_ memory\[20\]\[31\] memory\[21\]\[31\] memory\[22\]\[31\] memory\[23\]\[31\]
+ _1804_ _1805_ VGND VGND VPWR VPWR _2422_ sky130_fd_sc_hd__mux4_1
X_7567_ clknet_leaf_116_clk _1126_ VGND VGND VPWR VPWR memory\[23\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_15_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_120_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7498_ clknet_leaf_29_clk _1057_ VGND VGND VPWR VPWR memory\[24\]\[27\] sky130_fd_sc_hd__dfxtp_1
X_6518_ _2834_ _3326_ VGND VGND VPWR VPWR _3327_ sky130_fd_sc_hd__and2_1
XFILLER_0_113_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6449_ net1110 _3275_ _3280_ _3286_ VGND VGND VPWR VPWR _0232_ sky130_fd_sc_hd__a31o_1
X_6845__53 clknet_1_0__leaf__3445_ VGND VGND VPWR VPWR net198 sky130_fd_sc_hd__inv_2
XFILLER_0_98_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_97_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_110_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_104_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_104_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_712 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_88_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_119_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5820_ memory\[25\]\[12\] _2930_ _2934_ VGND VGND VPWR VPWR _2937_ sky130_fd_sc_hd__and3_1
X_5751_ _2911_ VGND VGND VPWR VPWR _2912_ sky130_fd_sc_hd__clkbuf_4
X_4702_ memory\[12\]\[26\] memory\[13\]\[26\] memory\[14\]\[26\] memory\[15\]\[26\]
+ _1965_ _1966_ VGND VGND VPWR VPWR _2350_ sky130_fd_sc_hd__mux4_1
XFILLER_0_84_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_114_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7421_ clknet_leaf_82_clk net131 VGND VGND VPWR VPWR memory\[0\]\[14\] sky130_fd_sc_hd__dfxtp_1
X_5682_ net19 VGND VGND VPWR VPWR _2863_ sky130_fd_sc_hd__clkbuf_4
X_4633_ _2276_ _2284_ VGND VGND VPWR VPWR _2285_ sky130_fd_sc_hd__and2_1
XFILLER_0_25_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold602 memory\[14\]\[11\] VGND VGND VPWR VPWR net811 sky130_fd_sc_hd__dlygate4sd3_1
X_7352_ clknet_leaf_114_clk _0911_ VGND VGND VPWR VPWR memory\[18\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_25_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4564_ memory\[24\]\[19\] memory\[25\]\[19\] memory\[26\]\[19\] memory\[27\]\[19\]
+ _2032_ _2033_ VGND VGND VPWR VPWR _2219_ sky130_fd_sc_hd__mux4_1
Xhold635 memory\[24\]\[26\] VGND VGND VPWR VPWR net844 sky130_fd_sc_hd__dlygate4sd3_1
X_6303_ _2891_ _3210_ VGND VGND VPWR VPWR _3216_ sky130_fd_sc_hd__and2_1
Xhold624 memory\[24\]\[28\] VGND VGND VPWR VPWR net833 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_102_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3515_ _1186_ _1219_ VGND VGND VPWR VPWR _1220_ sky130_fd_sc_hd__or2_1
X_7283_ clknet_leaf_15_clk _0842_ VGND VGND VPWR VPWR memory\[8\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_4_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold613 memory\[1\]\[7\] VGND VGND VPWR VPWR net822 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6234_ _2897_ _3167_ VGND VGND VPWR VPWR _3176_ sky130_fd_sc_hd__and2_1
Xhold668 memory\[21\]\[22\] VGND VGND VPWR VPWR net877 sky130_fd_sc_hd__dlygate4sd3_1
X_4495_ _2086_ _2149_ _2151_ _2153_ _2038_ VGND VGND VPWR VPWR _2154_ sky130_fd_sc_hd__a221o_1
Xhold657 memory\[4\]\[4\] VGND VGND VPWR VPWR net866 sky130_fd_sc_hd__dlygate4sd3_1
Xhold679 memory\[16\]\[9\] VGND VGND VPWR VPWR net888 sky130_fd_sc_hd__dlygate4sd3_1
Xhold646 memory\[21\]\[31\] VGND VGND VPWR VPWR net855 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_110_463 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_0_683 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6165_ net827 _3130_ _3094_ _3135_ VGND VGND VPWR VPWR _1124_ sky130_fd_sc_hd__a31o_1
XFILLER_0_40_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_951 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_940 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_962 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_995 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_984 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_973 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6096_ _3096_ VGND VGND VPWR VPWR _3097_ sky130_fd_sc_hd__buf_2
X_5116_ net918 _2601_ _2606_ _2622_ VGND VGND VPWR VPWR _0588_ sky130_fd_sc_hd__a31o_1
X_5047_ net1148 _2572_ _2573_ VGND VGND VPWR VPWR _2578_ sky130_fd_sc_hd__and3_1
XFILLER_0_67_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6998_ clknet_leaf_113_clk _0589_ VGND VGND VPWR VPWR memory\[26\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_5949_ net1043 _3006_ _3008_ _3012_ VGND VGND VPWR VPWR _1031_ sky130_fd_sc_hd__a31o_1
XFILLER_0_48_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7619_ clknet_leaf_27_clk _0153_ VGND VGND VPWR VPWR memory\[27\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_50_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_98_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_73_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_109_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4280_ _1801_ VGND VGND VPWR VPWR _1949_ sky130_fd_sc_hd__buf_4
XTAP_247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6921_ clknet_leaf_37_clk _0512_ VGND VGND VPWR VPWR memory\[15\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_71_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5803_ net1133 _2597_ _2921_ VGND VGND VPWR VPWR _2927_ sky130_fd_sc_hd__and3_1
X_6783_ _2671_ _3434_ _3435_ net311 VGND VGND VPWR VPWR _0417_ sky130_fd_sc_hd__a22o_1
X_3995_ _1676_ VGND VGND VPWR VPWR _0016_ sky130_fd_sc_hd__clkbuf_2
XFILLER_0_17_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5734_ net36 VGND VGND VPWR VPWR _2899_ sky130_fd_sc_hd__buf_4
XFILLER_0_60_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5665_ net45 VGND VGND VPWR VPWR _2851_ sky130_fd_sc_hd__clkbuf_4
X_7404_ clknet_leaf_27_clk _0963_ VGND VGND VPWR VPWR memory\[25\]\[29\] sky130_fd_sc_hd__dfxtp_1
X_4616_ _2268_ VGND VGND VPWR VPWR _0045_ sky130_fd_sc_hd__buf_1
XFILLER_0_88_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_7335_ clknet_leaf_48_clk _0894_ VGND VGND VPWR VPWR memory\[7\]\[24\] sky130_fd_sc_hd__dfxtp_1
Xhold410 memory\[20\]\[25\] VGND VGND VPWR VPWR net619 sky130_fd_sc_hd__dlygate4sd3_1
X_5596_ _2638_ _2804_ VGND VGND VPWR VPWR _2808_ sky130_fd_sc_hd__and2_1
XFILLER_0_102_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold454 memory\[3\]\[22\] VGND VGND VPWR VPWR net663 sky130_fd_sc_hd__dlygate4sd3_1
Xhold432 memory\[18\]\[31\] VGND VGND VPWR VPWR net641 sky130_fd_sc_hd__dlygate4sd3_1
Xhold421 memory\[20\]\[16\] VGND VGND VPWR VPWR net630 sky130_fd_sc_hd__dlygate4sd3_1
Xhold443 memory\[2\]\[7\] VGND VGND VPWR VPWR net652 sky130_fd_sc_hd__dlygate4sd3_1
X_4547_ _2113_ _2202_ VGND VGND VPWR VPWR _2203_ sky130_fd_sc_hd__or2_1
Xhold465 memory\[20\]\[29\] VGND VGND VPWR VPWR net674 sky130_fd_sc_hd__dlygate4sd3_1
X_7266_ net169 _0010_ VGND VGND VPWR VPWR net92 sky130_fd_sc_hd__dfxtp_2
Xhold476 memory\[22\]\[4\] VGND VGND VPWR VPWR net685 sky130_fd_sc_hd__dlygate4sd3_1
Xhold487 memory\[26\]\[14\] VGND VGND VPWR VPWR net696 sky130_fd_sc_hd__dlygate4sd3_1
X_4478_ memory\[4\]\[14\] memory\[5\]\[14\] memory\[6\]\[14\] memory\[7\]\[14\] _2014_
+ _2015_ VGND VGND VPWR VPWR _2138_ sky130_fd_sc_hd__mux4_1
XFILLER_0_110_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold498 memory\[22\]\[29\] VGND VGND VPWR VPWR net707 sky130_fd_sc_hd__dlygate4sd3_1
X_7197_ clknet_leaf_67_clk _0788_ VGND VGND VPWR VPWR memory\[14\]\[14\] sky130_fd_sc_hd__dfxtp_1
X_6217_ _3137_ VGND VGND VPWR VPWR _3166_ sky130_fd_sc_hd__clkbuf_4
X_6148_ net927 _3117_ _3122_ _3126_ VGND VGND VPWR VPWR _1116_ sky130_fd_sc_hd__a31o_1
XTAP_770 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_781 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_792 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6079_ _2895_ _3079_ VGND VGND VPWR VPWR _3086_ sky130_fd_sc_hd__and2_1
XFILLER_0_68_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_67_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_67_236 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_36_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_494 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_35_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_116_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_25_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_86_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3780_ _1165_ VGND VGND VPWR VPWR _1472_ sky130_fd_sc_hd__buf_6
XFILLER_0_6_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_109_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5450_ _2454_ _2767_ _2769_ net552 VGND VGND VPWR VPWR _0775_ sky130_fd_sc_hd__a22o_1
XFILLER_0_54_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4401_ _2063_ _2064_ _1848_ VGND VGND VPWR VPWR _2065_ sky130_fd_sc_hd__mux2_1
XFILLER_0_2_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_41_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_112_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5381_ _2467_ _2752_ _2753_ net771 VGND VGND VPWR VPWR _0722_ sky130_fd_sc_hd__a22o_1
X_4332_ memory\[12\]\[7\] memory\[13\]\[7\] memory\[14\]\[7\] memory\[15\]\[7\] _1973_
+ _1974_ VGND VGND VPWR VPWR _1999_ sky130_fd_sc_hd__mux4_1
X_7120_ clknet_leaf_11_clk _0711_ VGND VGND VPWR VPWR memory\[3\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_120_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7051_ clknet_leaf_40_clk _0642_ VGND VGND VPWR VPWR memory\[16\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_1_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4263_ _1871_ _1932_ VGND VGND VPWR VPWR _1933_ sky130_fd_sc_hd__or2_1
X_6002_ _2893_ _3036_ VGND VGND VPWR VPWR _3042_ sky130_fd_sc_hd__and2_1
XFILLER_0_10_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_4_7_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_7_0_clk sky130_fd_sc_hd__clkbuf_8
X_4194_ _1801_ VGND VGND VPWR VPWR _1867_ sky130_fd_sc_hd__buf_4
XFILLER_0_82_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6904_ clknet_leaf_73_clk _0495_ VGND VGND VPWR VPWR memory\[15\]\[10\] sky130_fd_sc_hd__dfxtp_1
X_7884_ clknet_leaf_52_clk _0418_ VGND VGND VPWR VPWR memory\[13\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_49_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3978_ memory\[20\]\[24\] memory\[21\]\[24\] memory\[22\]\[24\] memory\[23\]\[24\]
+ _1509_ _1510_ VGND VGND VPWR VPWR _1660_ sky130_fd_sc_hd__mux4_1
X_6766_ _2638_ _3432_ _3433_ net561 VGND VGND VPWR VPWR _0402_ sky130_fd_sc_hd__a22o_1
XFILLER_0_9_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5717_ net706 _2867_ _2880_ _2887_ VGND VGND VPWR VPWR _0892_ sky130_fd_sc_hd__a31o_1
XFILLER_0_9_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_667 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_122_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6697_ _3385_ VGND VGND VPWR VPWR _3400_ sky130_fd_sc_hd__buf_4
XFILLER_0_17_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5648_ net911 _2824_ _2833_ _2839_ VGND VGND VPWR VPWR _0871_ sky130_fd_sc_hd__a31o_1
Xclkbuf_0__3446_ _3446_ VGND VGND VPWR VPWR clknet_0__3446_ sky130_fd_sc_hd__clkbuf_16
X_5579_ _2730_ VGND VGND VPWR VPWR _2798_ sky130_fd_sc_hd__buf_4
X_5551__26 clknet_1_1__leaf__2786_ VGND VGND VPWR VPWR net171 sky130_fd_sc_hd__inv_2
XFILLER_0_60_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold240 memory\[14\]\[24\] VGND VGND VPWR VPWR net449 sky130_fd_sc_hd__dlygate4sd3_1
Xhold251 memory\[26\]\[30\] VGND VGND VPWR VPWR net460 sky130_fd_sc_hd__dlygate4sd3_1
Xhold262 memory\[17\]\[13\] VGND VGND VPWR VPWR net471 sky130_fd_sc_hd__dlygate4sd3_1
X_7318_ clknet_leaf_108_clk _0877_ VGND VGND VPWR VPWR memory\[7\]\[7\] sky130_fd_sc_hd__dfxtp_1
Xhold295 memory\[4\]\[30\] VGND VGND VPWR VPWR net504 sky130_fd_sc_hd__dlygate4sd3_1
Xhold284 memory\[13\]\[3\] VGND VGND VPWR VPWR net493 sky130_fd_sc_hd__dlygate4sd3_1
Xhold273 memory\[21\]\[1\] VGND VGND VPWR VPWR net482 sky130_fd_sc_hd__dlygate4sd3_1
X_7249_ net152 _0022_ VGND VGND VPWR VPWR net104 sky130_fd_sc_hd__dfxtp_1
XTAP_1700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_124 _2886_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_102 _1863_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_113 _2555_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_1722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_135 _3225_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_146 net105 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_1766 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1799 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1788 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1777 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_36_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_102_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput8 data_addr2[2] VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__buf_2
X_4950_ net1128 _2516_ _2513_ VGND VGND VPWR VPWR _2521_ sky130_fd_sc_hd__and3_1
X_3901_ _1585_ _1586_ _1472_ VGND VGND VPWR VPWR _1587_ sky130_fd_sc_hd__mux2_1
X_4881_ net12 net11 VGND VGND VPWR VPWR _2490_ sky130_fd_sc_hd__and2_2
XFILLER_0_117_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6620_ _2659_ _3373_ _3374_ net759 VGND VGND VPWR VPWR _0315_ sky130_fd_sc_hd__a22o_1
X_3832_ _1519_ _1520_ _1521_ VGND VGND VPWR VPWR _1522_ sky130_fd_sc_hd__mux2_1
XFILLER_0_46_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6551_ _2870_ _3339_ VGND VGND VPWR VPWR _3345_ sky130_fd_sc_hd__and2_1
XFILLER_0_82_570 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_54_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3763_ memory\[24\]\[13\] memory\[25\]\[13\] memory\[26\]\[13\] memory\[27\]\[13\]
+ _1353_ _1354_ VGND VGND VPWR VPWR _1456_ sky130_fd_sc_hd__mux4_1
X_5502_ _2631_ _2779_ _2780_ net445 VGND VGND VPWR VPWR _0816_ sky130_fd_sc_hd__a22o_1
X_6482_ _2876_ _3295_ VGND VGND VPWR VPWR _3305_ sky130_fd_sc_hd__and2_1
XFILLER_0_54_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3694_ _1154_ VGND VGND VPWR VPWR _1390_ sky130_fd_sc_hd__clkbuf_4
X_5433_ _2478_ _2763_ _2764_ net247 VGND VGND VPWR VPWR _0763_ sky130_fd_sc_hd__a22o_1
XFILLER_0_2_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_618 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5364_ _2748_ VGND VGND VPWR VPWR _2749_ sky130_fd_sc_hd__clkbuf_4
X_4315_ _1836_ _1982_ _1840_ VGND VGND VPWR VPWR _1983_ sky130_fd_sc_hd__o21a_1
X_7103_ clknet_leaf_87_clk _0694_ VGND VGND VPWR VPWR memory\[29\]\[16\] sky130_fd_sc_hd__dfxtp_1
X_5295_ _2657_ _2721_ VGND VGND VPWR VPWR _2723_ sky130_fd_sc_hd__and2_1
X_7437__115 VGND VGND VPWR VPWR _7437__115/HI net115 sky130_fd_sc_hd__conb_1
X_4246_ memory\[12\]\[3\] memory\[13\]\[3\] memory\[14\]\[3\] memory\[15\]\[3\] _1877_
+ _1878_ VGND VGND VPWR VPWR _1917_ sky130_fd_sc_hd__mux4_2
X_7034_ clknet_leaf_88_clk _0625_ VGND VGND VPWR VPWR memory\[16\]\[11\] sky130_fd_sc_hd__dfxtp_1
X_4177_ net5 VGND VGND VPWR VPWR _1851_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_97_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1029 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1018 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1007 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7936_ net199 _0040_ VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__dfxtp_2
X_7867_ clknet_leaf_65_clk _0401_ VGND VGND VPWR VPWR memory\[13\]\[12\] sky130_fd_sc_hd__dfxtp_1
X_6818_ _2659_ _3443_ _3444_ net659 VGND VGND VPWR VPWR _0443_ sky130_fd_sc_hd__a22o_1
XFILLER_0_108_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_108_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7798_ clknet_leaf_16_clk _0332_ VGND VGND VPWR VPWR memory\[12\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_6749_ _2450_ _3428_ VGND VGND VPWR VPWR _3430_ sky130_fd_sc_hd__nor2_4
XFILLER_0_80_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_264 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_14_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_103_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_113_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_12_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_51_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5080_ net1142 _2585_ _2586_ VGND VGND VPWR VPWR _2596_ sky130_fd_sc_hd__and3_1
X_4100_ _1774_ _1775_ _1166_ VGND VGND VPWR VPWR _1776_ sky130_fd_sc_hd__mux2_1
XFILLER_0_47_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4031_ _1710_ VGND VGND VPWR VPWR _0018_ sky130_fd_sc_hd__buf_1
XFILLER_0_37_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5530__7 clknet_1_1__leaf__2784_ VGND VGND VPWR VPWR net152 sky130_fd_sc_hd__inv_2
XFILLER_0_78_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5982_ net664 _3021_ _3022_ _3030_ VGND VGND VPWR VPWR _1046_ sky130_fd_sc_hd__a31o_1
X_7721_ clknet_leaf_72_clk _0255_ VGND VGND VPWR VPWR memory\[5\]\[26\] sky130_fd_sc_hd__dfxtp_1
X_4933_ _2489_ VGND VGND VPWR VPWR _2510_ sky130_fd_sc_hd__clkbuf_4
X_4864_ net32 VGND VGND VPWR VPWR _2481_ sky130_fd_sc_hd__buf_4
X_7652_ clknet_leaf_39_clk _0186_ VGND VGND VPWR VPWR memory\[19\]\[21\] sky130_fd_sc_hd__dfxtp_1
XANTENNA_13 _1812_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_105_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_24 _2206_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_46 _2876_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4795_ _2429_ _2437_ _1827_ VGND VGND VPWR VPWR _2438_ sky130_fd_sc_hd__mux2_1
X_7583_ clknet_leaf_95_clk _1142_ VGND VGND VPWR VPWR memory\[23\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_6_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_35 _2634_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_57 _3009_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6603_ _2627_ _3368_ _3370_ net916 VGND VGND VPWR VPWR _0302_ sky130_fd_sc_hd__a22o_1
X_3815_ _1504_ _1505_ _1166_ VGND VGND VPWR VPWR _1506_ sky130_fd_sc_hd__mux2_1
X_6534_ net787 _3333_ _3324_ _3335_ VGND VGND VPWR VPWR _0268_ sky130_fd_sc_hd__a31o_1
XANTENNA_79 net77 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_68 net59 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3746_ _1394_ _1439_ VGND VGND VPWR VPWR _1440_ sky130_fd_sc_hd__or2_1
X_6465_ _2858_ _3295_ VGND VGND VPWR VPWR _3296_ sky130_fd_sc_hd__and2_1
XFILLER_0_42_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_112_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3677_ memory\[16\]\[9\] memory\[17\]\[9\] memory\[18\]\[9\] memory\[19\]\[9\] _1349_
+ _1350_ VGND VGND VPWR VPWR _1374_ sky130_fd_sc_hd__mux4_1
X_5416_ _2461_ _2758_ _2760_ net324 VGND VGND VPWR VPWR _0750_ sky130_fd_sc_hd__a22o_1
XFILLER_0_113_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6396_ net930 _3249_ _3250_ _3255_ VGND VGND VPWR VPWR _0210_ sky130_fd_sc_hd__a31o_1
X_5347_ _2738_ VGND VGND VPWR VPWR _2744_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_11_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_11_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5278_ _2640_ _2708_ VGND VGND VPWR VPWR _2713_ sky130_fd_sc_hd__and2_1
X_7017_ clknet_leaf_30_clk _0608_ VGND VGND VPWR VPWR memory\[26\]\[26\] sky130_fd_sc_hd__dfxtp_1
X_4229_ _1900_ VGND VGND VPWR VPWR _0054_ sky130_fd_sc_hd__clkbuf_1
X_7919_ net182 _0032_ VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__dfxtp_2
XFILLER_0_93_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_120 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_92_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_92_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_108_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_69_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_68_183 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4580_ memory\[24\]\[20\] memory\[25\]\[20\] memory\[26\]\[20\] memory\[27\]\[20\]
+ _1872_ _1873_ VGND VGND VPWR VPWR _2234_ sky130_fd_sc_hd__mux4_1
X_7427__125 VGND VGND VPWR VPWR _7427__125/HI net125 sky130_fd_sc_hd__conb_1
XFILLER_0_71_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput11 data_addr[0] VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__buf_4
Xinput22 data_in[15] VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__clkbuf_2
X_3600_ _1177_ _1300_ _1181_ VGND VGND VPWR VPWR _1301_ sky130_fd_sc_hd__o21a_1
XFILLER_0_4_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput33 data_in[25] VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__clkbuf_4
Xinput44 data_in[6] VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_3_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3531_ _1155_ _1230_ _1232_ _1234_ _1184_ VGND VGND VPWR VPWR _1235_ sky130_fd_sc_hd__a221o_1
Xhold806 memory\[15\]\[27\] VGND VGND VPWR VPWR net1015 sky130_fd_sc_hd__dlygate4sd3_1
Xhold817 memory\[26\]\[15\] VGND VGND VPWR VPWR net1026 sky130_fd_sc_hd__dlygate4sd3_1
Xhold828 memory\[23\]\[14\] VGND VGND VPWR VPWR net1037 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_3_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3462_ net8 VGND VGND VPWR VPWR _1168_ sky130_fd_sc_hd__clkbuf_8
Xhold839 memory\[20\]\[27\] VGND VGND VPWR VPWR net1048 sky130_fd_sc_hd__dlygate4sd3_1
X_6250_ _2838_ _3184_ VGND VGND VPWR VPWR _3186_ sky130_fd_sc_hd__and2_1
XFILLER_0_110_667 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_110_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5201_ _2681_ VGND VGND VPWR VPWR _2682_ sky130_fd_sc_hd__buf_4
X_6181_ _3145_ VGND VGND VPWR VPWR _3146_ sky130_fd_sc_hd__clkbuf_4
X_5132_ net18 VGND VGND VPWR VPWR _2634_ sky130_fd_sc_hd__buf_4
X_7434__118 VGND VGND VPWR VPWR _7434__118/HI net118 sky130_fd_sc_hd__conb_1
X_5063_ _2475_ _2584_ _2587_ VGND VGND VPWR VPWR _0570_ sky130_fd_sc_hd__a21o_1
X_4014_ memory\[20\]\[26\] memory\[21\]\[26\] memory\[22\]\[26\] memory\[23\]\[26\]
+ _1240_ _1241_ VGND VGND VPWR VPWR _1694_ sky130_fd_sc_hd__mux4_1
XFILLER_0_79_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_94_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5965_ net683 _3006_ _3008_ _3020_ VGND VGND VPWR VPWR _1039_ sky130_fd_sc_hd__a31o_1
XFILLER_0_47_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_118_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4916_ _2481_ _2499_ _2500_ net412 VGND VGND VPWR VPWR _0509_ sky130_fd_sc_hd__a22o_1
X_5896_ _2730_ VGND VGND VPWR VPWR _2981_ sky130_fd_sc_hd__clkbuf_4
X_7704_ clknet_leaf_102_clk _0238_ VGND VGND VPWR VPWR memory\[5\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_75_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7635_ clknet_leaf_116_clk _0169_ VGND VGND VPWR VPWR memory\[19\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_4847_ _2471_ _2464_ _2465_ net805 VGND VGND VPWR VPWR _0469_ sky130_fd_sc_hd__a22o_1
XFILLER_0_28_570 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_105_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_90_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_105_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4778_ _2421_ VGND VGND VPWR VPWR _0055_ sky130_fd_sc_hd__buf_1
X_7566_ clknet_leaf_8_clk _1125_ VGND VGND VPWR VPWR memory\[20\]\[31\] sky130_fd_sc_hd__dfxtp_1
X_7497_ clknet_leaf_29_clk _1056_ VGND VGND VPWR VPWR memory\[24\]\[26\] sky130_fd_sc_hd__dfxtp_1
X_3729_ memory\[0\]\[11\] memory\[1\]\[11\] memory\[2\]\[11\] memory\[3\]\[11\] _1363_
+ _1364_ VGND VGND VPWR VPWR _1424_ sky130_fd_sc_hd__mux4_1
X_6517_ _3325_ VGND VGND VPWR VPWR _3326_ sky130_fd_sc_hd__buf_2
X_6448_ _2842_ _3282_ VGND VGND VPWR VPWR _3286_ sky130_fd_sc_hd__and2_1
X_6379_ net316 _3233_ _3236_ _3245_ VGND VGND VPWR VPWR _0203_ sky130_fd_sc_hd__a31o_1
XFILLER_0_101_689 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_11_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_98_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_97_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6860__3 clknet_1_0__leaf__2783_ VGND VGND VPWR VPWR net148 sky130_fd_sc_hd__inv_2
XFILLER_0_66_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_1_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_100_clk clknet_4_6_0_clk VGND VGND VPWR VPWR clknet_leaf_100_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_119_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_89_702 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5750_ _2451_ _2909_ VGND VGND VPWR VPWR _2911_ sky130_fd_sc_hd__nor2_4
XFILLER_0_56_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4701_ _2101_ _2348_ VGND VGND VPWR VPWR _2349_ sky130_fd_sc_hd__or2_1
XTAP_1190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5681_ net623 _2844_ _2857_ _2862_ VGND VGND VPWR VPWR _0881_ sky130_fd_sc_hd__a31o_1
X_4632_ _2278_ _2280_ _2283_ _1797_ _2249_ VGND VGND VPWR VPWR _2284_ sky130_fd_sc_hd__a221o_1
XFILLER_0_71_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7420_ clknet_leaf_82_clk net132 VGND VGND VPWR VPWR memory\[0\]\[13\] sky130_fd_sc_hd__dfxtp_1
Xhold603 memory\[17\]\[24\] VGND VGND VPWR VPWR net812 sky130_fd_sc_hd__dlygate4sd3_1
X_7351_ clknet_leaf_113_clk _0910_ VGND VGND VPWR VPWR memory\[18\]\[8\] sky130_fd_sc_hd__dfxtp_1
X_4563_ _2216_ _2217_ _1819_ VGND VGND VPWR VPWR _2218_ sky130_fd_sc_hd__mux2_1
Xhold625 memory\[13\]\[29\] VGND VGND VPWR VPWR net834 sky130_fd_sc_hd__dlygate4sd3_1
X_6302_ net568 _3213_ _3209_ _3215_ VGND VGND VPWR VPWR _0156_ sky130_fd_sc_hd__a31o_1
X_3514_ memory\[8\]\[1\] memory\[9\]\[1\] memory\[10\]\[1\] memory\[11\]\[1\] _1188_
+ _1190_ VGND VGND VPWR VPWR _1219_ sky130_fd_sc_hd__mux4_1
X_7282_ clknet_leaf_20_clk _0841_ VGND VGND VPWR VPWR memory\[8\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_69_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4494_ _2116_ _2152_ _2118_ VGND VGND VPWR VPWR _2153_ sky130_fd_sc_hd__o21a_1
Xhold614 memory\[16\]\[5\] VGND VGND VPWR VPWR net823 sky130_fd_sc_hd__dlygate4sd3_1
Xhold636 memory\[30\]\[4\] VGND VGND VPWR VPWR net845 sky130_fd_sc_hd__dlygate4sd3_1
X_6233_ net937 _3172_ _3166_ _3175_ VGND VGND VPWR VPWR _1152_ sky130_fd_sc_hd__a31o_1
Xhold669 memory\[13\]\[6\] VGND VGND VPWR VPWR net878 sky130_fd_sc_hd__dlygate4sd3_1
Xhold647 memory\[11\]\[0\] VGND VGND VPWR VPWR net856 sky130_fd_sc_hd__dlygate4sd3_1
Xhold658 memory\[30\]\[8\] VGND VGND VPWR VPWR net867 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_110_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_651 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6164_ _2903_ _3096_ VGND VGND VPWR VPWR _3135_ sky130_fd_sc_hd__and2_1
XFILLER_0_0_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_930 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_952 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_941 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6095_ _2440_ _2441_ _2690_ _3093_ VGND VGND VPWR VPWR _3096_ sky130_fd_sc_hd__and4_4
XTAP_996 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_985 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_974 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5115_ _2621_ _2609_ VGND VGND VPWR VPWR _2622_ sky130_fd_sc_hd__and2_1
XTAP_963 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5046_ _2468_ _2571_ _2577_ VGND VGND VPWR VPWR _0563_ sky130_fd_sc_hd__a21o_1
XFILLER_0_33_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_79_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6997_ clknet_leaf_2_clk _0588_ VGND VGND VPWR VPWR memory\[26\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_48_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5948_ _2838_ _3010_ VGND VGND VPWR VPWR _3012_ sky130_fd_sc_hd__and2_1
XFILLER_0_118_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5879_ net1052 _2968_ _2963_ _2971_ VGND VGND VPWR VPWR _1002_ sky130_fd_sc_hd__a31o_1
XFILLER_0_35_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_105_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7618_ clknet_leaf_100_clk _0152_ VGND VGND VPWR VPWR memory\[27\]\[19\] sky130_fd_sc_hd__dfxtp_1
X_7549_ clknet_leaf_94_clk _1108_ VGND VGND VPWR VPWR memory\[20\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_101_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7417__135 VGND VGND VPWR VPWR _7417__135/HI net135 sky130_fd_sc_hd__conb_1
XFILLER_0_105_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_109_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_292 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_93_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5557__32 clknet_1_1__leaf__2786_ VGND VGND VPWR VPWR net177 sky130_fd_sc_hd__inv_2
XFILLER_0_26_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7424__128 VGND VGND VPWR VPWR _7424__128/HI net128 sky130_fd_sc_hd__conb_1
XTAP_248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6920_ clknet_leaf_53_clk _0511_ VGND VGND VPWR VPWR memory\[15\]\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_77_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_306 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5802_ _2457_ _2919_ _2926_ VGND VGND VPWR VPWR _0938_ sky130_fd_sc_hd__a21o_1
X_6782_ _2669_ _3434_ _3435_ net453 VGND VGND VPWR VPWR _0416_ sky130_fd_sc_hd__a22o_1
X_3994_ _1667_ _1675_ VGND VGND VPWR VPWR _1676_ sky130_fd_sc_hd__and2_1
XFILLER_0_9_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5733_ net969 _2890_ _2880_ _2898_ VGND VGND VPWR VPWR _0897_ sky130_fd_sc_hd__a31o_1
XFILLER_0_17_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5664_ net632 _2844_ _2833_ _2850_ VGND VGND VPWR VPWR _0876_ sky130_fd_sc_hd__a31o_1
X_7403_ clknet_leaf_28_clk _0962_ VGND VGND VPWR VPWR memory\[25\]\[28\] sky130_fd_sc_hd__dfxtp_1
X_4615_ _2259_ _2267_ VGND VGND VPWR VPWR _2268_ sky130_fd_sc_hd__and2_1
X_5595_ net1070 _2798_ _2803_ _2807_ VGND VGND VPWR VPWR _0850_ sky130_fd_sc_hd__a31o_1
XFILLER_0_111_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7334_ clknet_leaf_65_clk _0893_ VGND VGND VPWR VPWR memory\[7\]\[23\] sky130_fd_sc_hd__dfxtp_1
Xhold411 memory\[15\]\[17\] VGND VGND VPWR VPWR net620 sky130_fd_sc_hd__dlygate4sd3_1
Xhold400 memory\[14\]\[31\] VGND VGND VPWR VPWR net609 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_4_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4546_ memory\[24\]\[18\] memory\[25\]\[18\] memory\[26\]\[18\] memory\[27\]\[18\]
+ _2032_ _2033_ VGND VGND VPWR VPWR _2202_ sky130_fd_sc_hd__mux4_1
Xhold422 memory\[12\]\[7\] VGND VGND VPWR VPWR net631 sky130_fd_sc_hd__dlygate4sd3_1
Xhold433 memory\[20\]\[31\] VGND VGND VPWR VPWR net642 sky130_fd_sc_hd__dlygate4sd3_1
Xhold444 memory\[22\]\[13\] VGND VGND VPWR VPWR net653 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_587 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold477 memory\[9\]\[26\] VGND VGND VPWR VPWR net686 sky130_fd_sc_hd__dlygate4sd3_1
X_7265_ net168 _0009_ VGND VGND VPWR VPWR net91 sky130_fd_sc_hd__dfxtp_1
Xhold455 memory\[24\]\[16\] VGND VGND VPWR VPWR net664 sky130_fd_sc_hd__dlygate4sd3_1
X_4477_ _2131_ _2133_ _2136_ _1978_ _2038_ VGND VGND VPWR VPWR _2137_ sky130_fd_sc_hd__a221o_1
Xhold466 memory\[28\]\[1\] VGND VGND VPWR VPWR net675 sky130_fd_sc_hd__dlygate4sd3_1
Xhold488 memory\[4\]\[21\] VGND VGND VPWR VPWR net697 sky130_fd_sc_hd__dlygate4sd3_1
Xhold499 memory\[24\]\[30\] VGND VGND VPWR VPWR net708 sky130_fd_sc_hd__dlygate4sd3_1
X_7196_ clknet_leaf_67_clk _0787_ VGND VGND VPWR VPWR memory\[14\]\[13\] sky130_fd_sc_hd__dfxtp_1
X_6216_ net943 _3159_ _3153_ _3165_ VGND VGND VPWR VPWR _1145_ sky130_fd_sc_hd__a31o_1
X_6147_ _2886_ _3123_ VGND VGND VPWR VPWR _3126_ sky130_fd_sc_hd__and2_1
XFILLER_0_0_492 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_782 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_771 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_793 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6078_ net616 _3075_ _3078_ _3085_ VGND VGND VPWR VPWR _1087_ sky130_fd_sc_hd__a31o_1
X_5029_ _2459_ _2556_ _2567_ VGND VGND VPWR VPWR _0556_ sky130_fd_sc_hd__a21o_1
XFILLER_0_95_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_440 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_75_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_118_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_121_537 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_101_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_116_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4400_ memory\[0\]\[10\] memory\[1\]\[10\] memory\[2\]\[10\] memory\[3\]\[10\] _1845_
+ _1846_ VGND VGND VPWR VPWR _2064_ sky130_fd_sc_hd__mux4_1
X_5380_ _2466_ _2752_ _2753_ net320 VGND VGND VPWR VPWR _0721_ sky130_fd_sc_hd__a22o_1
X_4331_ _1829_ _1997_ VGND VGND VPWR VPWR _1998_ sky130_fd_sc_hd__or2_1
X_7050_ clknet_leaf_32_clk _0641_ VGND VGND VPWR VPWR memory\[16\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_5_13 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4262_ memory\[8\]\[4\] memory\[9\]\[4\] memory\[10\]\[4\] memory\[11\]\[4\] _1913_
+ _1914_ VGND VGND VPWR VPWR _1932_ sky130_fd_sc_hd__mux4_1
X_6001_ net942 _3034_ _3035_ _3041_ VGND VGND VPWR VPWR _1054_ sky130_fd_sc_hd__a31o_1
XFILLER_0_66_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4193_ _1799_ VGND VGND VPWR VPWR _1866_ sky130_fd_sc_hd__buf_6
XFILLER_0_82_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6903_ clknet_leaf_23_clk _0494_ VGND VGND VPWR VPWR memory\[15\]\[9\] sky130_fd_sc_hd__dfxtp_1
X_7883_ clknet_leaf_52_clk _0417_ VGND VGND VPWR VPWR memory\[13\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_119_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_119_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3977_ _1659_ VGND VGND VPWR VPWR _0015_ sky130_fd_sc_hd__clkbuf_1
X_6765_ _2636_ _3432_ _3433_ net963 VGND VGND VPWR VPWR _0401_ sky130_fd_sc_hd__a22o_1
XFILLER_0_57_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5716_ _2886_ _2882_ VGND VGND VPWR VPWR _2887_ sky130_fd_sc_hd__and2_1
XFILLER_0_57_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_679 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_33_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_122_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6696_ net740 _3393_ _3386_ _3399_ VGND VGND VPWR VPWR _0366_ sky130_fd_sc_hd__a31o_1
X_5536__13 clknet_1_1__leaf__2784_ VGND VGND VPWR VPWR net158 sky130_fd_sc_hd__inv_2
XFILLER_0_115_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_295 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_7407__145 VGND VGND VPWR VPWR _7407__145/HI net145 sky130_fd_sc_hd__conb_1
X_5647_ _2838_ _2836_ VGND VGND VPWR VPWR _2839_ sky130_fd_sc_hd__and2_1
XFILLER_0_31_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5578_ net952 _2731_ _2789_ _2797_ VGND VGND VPWR VPWR _0843_ sky130_fd_sc_hd__a31o_1
XFILLER_0_5_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_0__3445_ _3445_ VGND VGND VPWR VPWR clknet_0__3445_ sky130_fd_sc_hd__clkbuf_16
Xhold230 memory\[9\]\[11\] VGND VGND VPWR VPWR net439 sky130_fd_sc_hd__dlygate4sd3_1
Xhold241 memory\[20\]\[19\] VGND VGND VPWR VPWR net450 sky130_fd_sc_hd__dlygate4sd3_1
X_4529_ memory\[16\]\[17\] memory\[17\]\[17\] memory\[18\]\[17\] memory\[19\]\[17\]
+ _1970_ _1971_ VGND VGND VPWR VPWR _2186_ sky130_fd_sc_hd__mux4_1
X_7317_ clknet_leaf_107_clk _0876_ VGND VGND VPWR VPWR memory\[7\]\[6\] sky130_fd_sc_hd__dfxtp_1
Xhold252 memory\[16\]\[19\] VGND VGND VPWR VPWR net461 sky130_fd_sc_hd__dlygate4sd3_1
Xhold263 memory\[14\]\[26\] VGND VGND VPWR VPWR net472 sky130_fd_sc_hd__dlygate4sd3_1
Xhold296 memory\[9\]\[29\] VGND VGND VPWR VPWR net505 sky130_fd_sc_hd__dlygate4sd3_1
Xhold274 memory\[22\]\[9\] VGND VGND VPWR VPWR net483 sky130_fd_sc_hd__dlygate4sd3_1
Xhold285 memory\[5\]\[9\] VGND VGND VPWR VPWR net494 sky130_fd_sc_hd__dlygate4sd3_1
X_7248_ net151 _0011_ VGND VGND VPWR VPWR net93 sky130_fd_sc_hd__dfxtp_2
X_7179_ clknet_leaf_64_clk _0770_ VGND VGND VPWR VPWR memory\[2\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_99_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_125 _2888_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_114 _2555_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7414__138 VGND VGND VPWR VPWR _7414__138/HI net138 sky130_fd_sc_hd__conb_1
XANTENNA_103 _1872_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_1723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_147 _1939_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_136 _3237_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_1767 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_80_clk clknet_4_7_0_clk VGND VGND VPWR VPWR clknet_leaf_80_clk sky130_fd_sc_hd__clkbuf_16
XTAP_1789 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1778 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_102_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_11_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_17_690 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_51_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput9 data_addr2[3] VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_36_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_99_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3900_ memory\[16\]\[20\] memory\[17\]\[20\] memory\[18\]\[20\] memory\[19\]\[20\]
+ _1547_ _1548_ VGND VGND VPWR VPWR _1586_ sky130_fd_sc_hd__mux4_1
XFILLER_0_86_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4880_ _2442_ VGND VGND VPWR VPWR _2489_ sky130_fd_sc_hd__buf_2
Xclkbuf_leaf_71_clk clknet_4_13_0_clk VGND VGND VPWR VPWR clknet_leaf_71_clk sky130_fd_sc_hd__clkbuf_16
X_3831_ _1165_ VGND VGND VPWR VPWR _1521_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_27_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_117_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6550_ net698 _3333_ _3338_ _3344_ VGND VGND VPWR VPWR _0275_ sky130_fd_sc_hd__a31o_1
X_3762_ _1453_ _1454_ _1279_ VGND VGND VPWR VPWR _1455_ sky130_fd_sc_hd__mux2_1
XFILLER_0_39_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_82_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5501_ _2777_ VGND VGND VPWR VPWR _2780_ sky130_fd_sc_hd__clkbuf_4
X_6481_ _2508_ VGND VGND VPWR VPWR _3304_ sky130_fd_sc_hd__buf_4
X_3693_ _1389_ VGND VGND VPWR VPWR _0031_ sky130_fd_sc_hd__clkbuf_1
X_5432_ _2475_ _2763_ _2764_ net944 VGND VGND VPWR VPWR _0762_ sky130_fd_sc_hd__a22o_1
XFILLER_0_42_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5363_ _2747_ VGND VGND VPWR VPWR _2748_ sky130_fd_sc_hd__buf_4
X_4314_ memory\[12\]\[6\] memory\[13\]\[6\] memory\[14\]\[6\] memory\[15\]\[6\] _1973_
+ _1974_ VGND VGND VPWR VPWR _1982_ sky130_fd_sc_hd__mux4_1
XFILLER_0_10_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7102_ clknet_leaf_87_clk _0693_ VGND VGND VPWR VPWR memory\[29\]\[15\] sky130_fd_sc_hd__dfxtp_1
X_5294_ net967 _2717_ _2720_ _2722_ VGND VGND VPWR VPWR _0666_ sky130_fd_sc_hd__a31o_1
X_4245_ _1871_ _1915_ VGND VGND VPWR VPWR _1916_ sky130_fd_sc_hd__or2_1
X_7033_ clknet_leaf_90_clk _0624_ VGND VGND VPWR VPWR memory\[16\]\[10\] sky130_fd_sc_hd__dfxtp_1
X_4176_ _1797_ VGND VGND VPWR VPWR _1850_ sky130_fd_sc_hd__buf_4
XFILLER_0_89_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1019 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1008 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7935_ net198 _0039_ VGND VGND VPWR VPWR net57 sky130_fd_sc_hd__dfxtp_2
Xclkbuf_leaf_62_clk clknet_4_15_0_clk VGND VGND VPWR VPWR clknet_leaf_62_clk sky130_fd_sc_hd__clkbuf_16
X_7866_ clknet_leaf_71_clk _0400_ VGND VGND VPWR VPWR memory\[13\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_65_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6817_ _2657_ _3443_ _3444_ net938 VGND VGND VPWR VPWR _0442_ sky130_fd_sc_hd__a22o_1
XFILLER_0_77_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7797_ clknet_leaf_19_clk _0331_ VGND VGND VPWR VPWR memory\[12\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_18_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6748_ _3428_ VGND VGND VPWR VPWR _3429_ sky130_fd_sc_hd__clkbuf_4
X_6679_ net339 _3359_ _3386_ _3390_ VGND VGND VPWR VPWR _0358_ sky130_fd_sc_hd__a31o_1
XFILLER_0_60_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_53_clk clknet_4_14_0_clk VGND VGND VPWR VPWR clknet_leaf_53_clk sky130_fd_sc_hd__clkbuf_16
XTAP_1542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_1575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_113_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_4_6_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_6_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_107_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_24_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_122_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_122_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_122_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_11_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4030_ _1701_ _1709_ VGND VGND VPWR VPWR _1710_ sky130_fd_sc_hd__and2_1
XFILLER_0_87_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5981_ _2872_ _3023_ VGND VGND VPWR VPWR _3030_ sky130_fd_sc_hd__and2_1
X_7720_ clknet_leaf_47_clk _0254_ VGND VGND VPWR VPWR memory\[5\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_87_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4932_ _2508_ VGND VGND VPWR VPWR _2509_ sky130_fd_sc_hd__buf_4
Xclkbuf_leaf_44_clk clknet_4_12_0_clk VGND VGND VPWR VPWR clknet_leaf_44_clk sky130_fd_sc_hd__clkbuf_16
X_7651_ clknet_leaf_34_clk _0185_ VGND VGND VPWR VPWR memory\[19\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_86_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4863_ _2480_ _2476_ _2477_ net437 VGND VGND VPWR VPWR _0476_ sky130_fd_sc_hd__a22o_1
XANTENNA_14 _1812_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6602_ _2625_ _3368_ _3370_ net867 VGND VGND VPWR VPWR _0301_ sky130_fd_sc_hd__a22o_1
XANTENNA_25 _2269_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4794_ _2431_ _2433_ _2436_ _1798_ VGND VGND VPWR VPWR _2437_ sky130_fd_sc_hd__a22o_1
X_7582_ clknet_leaf_109_clk _1141_ VGND VGND VPWR VPWR memory\[23\]\[15\] sky130_fd_sc_hd__dfxtp_1
XANTENNA_47 _2909_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_36 _2682_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3814_ memory\[0\]\[15\] memory\[1\]\[15\] memory\[2\]\[15\] memory\[3\]\[15\] _1271_
+ _1272_ VGND VGND VPWR VPWR _1505_ sky130_fd_sc_hd__mux4_1
XANTENNA_69 net61 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6533_ _2851_ _3326_ VGND VGND VPWR VPWR _3335_ sky130_fd_sc_hd__and2_1
XANTENNA_58 _3096_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3745_ memory\[24\]\[12\] memory\[25\]\[12\] memory\[26\]\[12\] memory\[27\]\[12\]
+ _1353_ _1354_ VGND VGND VPWR VPWR _1439_ sky130_fd_sc_hd__mux4_1
X_6464_ _3281_ VGND VGND VPWR VPWR _3295_ sky130_fd_sc_hd__buf_2
Xoutput110 net110 VGND VGND VPWR VPWR data_out2[6] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_88_52 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_88_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3676_ memory\[20\]\[9\] memory\[21\]\[9\] memory\[22\]\[9\] memory\[23\]\[9\] _1312_
+ _1313_ VGND VGND VPWR VPWR _1373_ sky130_fd_sc_hd__mux4_1
X_5415_ _2460_ _2758_ _2760_ net652 VGND VGND VPWR VPWR _0749_ sky130_fd_sc_hd__a22o_1
XFILLER_0_63_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6395_ _2865_ _3251_ VGND VGND VPWR VPWR _3255_ sky130_fd_sc_hd__and2_1
XFILLER_0_112_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5346_ _2474_ _2742_ _2743_ net276 VGND VGND VPWR VPWR _0697_ sky130_fd_sc_hd__a22o_1
XFILLER_0_10_184 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5277_ net541 _2704_ _2707_ _2712_ VGND VGND VPWR VPWR _0659_ sky130_fd_sc_hd__a31o_1
X_7016_ clknet_leaf_29_clk _0607_ VGND VGND VPWR VPWR memory\[26\]\[25\] sky130_fd_sc_hd__dfxtp_1
X_4228_ _1891_ _1899_ VGND VGND VPWR VPWR _1900_ sky130_fd_sc_hd__and2_1
X_4159_ _1832_ VGND VGND VPWR VPWR _1833_ sky130_fd_sc_hd__buf_4
XFILLER_0_97_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7918_ clknet_leaf_14_clk _0452_ VGND VGND VPWR VPWR memory\[17\]\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_38_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_35_clk clknet_4_11_0_clk VGND VGND VPWR VPWR clknet_leaf_35_clk sky130_fd_sc_hd__clkbuf_16
X_7849_ clknet_leaf_52_clk _0383_ VGND VGND VPWR VPWR memory\[9\]\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_92_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_69_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_26_clk clknet_4_8_0_clk VGND VGND VPWR VPWR clknet_leaf_26_clk sky130_fd_sc_hd__clkbuf_16
XTAP_1350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_688 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_71_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput12 data_addr[1] VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__buf_4
XFILLER_0_52_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput34 data_in[26] VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__clkbuf_2
Xinput45 data_in[7] VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput23 data_in[16] VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__clkbuf_2
X_3530_ _1177_ _1233_ _1181_ VGND VGND VPWR VPWR _1234_ sky130_fd_sc_hd__o21a_1
Xhold818 memory\[4\]\[18\] VGND VGND VPWR VPWR net1027 sky130_fd_sc_hd__dlygate4sd3_1
Xhold807 memory\[4\]\[0\] VGND VGND VPWR VPWR net1016 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_52_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_122_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold829 memory\[26\]\[22\] VGND VGND VPWR VPWR net1038 sky130_fd_sc_hd__dlygate4sd3_1
X_3461_ _1160_ _1163_ _1166_ VGND VGND VPWR VPWR _1167_ sky130_fd_sc_hd__mux2_1
XFILLER_0_110_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5200_ _2443_ _2440_ _2680_ _2442_ VGND VGND VPWR VPWR _2681_ sky130_fd_sc_hd__and4_1
X_6180_ _2507_ VGND VGND VPWR VPWR _3145_ sky130_fd_sc_hd__buf_4
XFILLER_0_110_679 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5131_ net555 _2629_ _2630_ _2633_ VGND VGND VPWR VPWR _0592_ sky130_fd_sc_hd__a31o_1
X_5062_ memory\[6\]\[20\] _2585_ _2586_ VGND VGND VPWR VPWR _2587_ sky130_fd_sc_hd__and3_1
X_4013_ _1693_ VGND VGND VPWR VPWR _0017_ sky130_fd_sc_hd__clkbuf_1
Xclkbuf_leaf_17_clk clknet_4_9_0_clk VGND VGND VPWR VPWR clknet_leaf_17_clk sky130_fd_sc_hd__clkbuf_16
X_5964_ _2855_ _3010_ VGND VGND VPWR VPWR _3020_ sky130_fd_sc_hd__and2_1
X_7703_ clknet_leaf_103_clk _0237_ VGND VGND VPWR VPWR memory\[5\]\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_118_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4915_ _2480_ _2499_ _2500_ net546 VGND VGND VPWR VPWR _0508_ sky130_fd_sc_hd__a22o_1
X_5895_ net793 _2968_ _2977_ _2980_ VGND VGND VPWR VPWR _1009_ sky130_fd_sc_hd__a31o_1
X_7634_ clknet_leaf_116_clk _0168_ VGND VGND VPWR VPWR memory\[19\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_4846_ net23 VGND VGND VPWR VPWR _2471_ sky130_fd_sc_hd__buf_4
X_7565_ clknet_leaf_20_clk _1124_ VGND VGND VPWR VPWR memory\[20\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_28_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_105_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_99_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4777_ _2412_ _2420_ VGND VGND VPWR VPWR _2421_ sky130_fd_sc_hd__and2_1
X_6516_ _2690_ _2501_ _3093_ VGND VGND VPWR VPWR _3325_ sky130_fd_sc_hd__and3_4
X_7496_ clknet_leaf_28_clk _1055_ VGND VGND VPWR VPWR memory\[24\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_30_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3728_ memory\[4\]\[11\] memory\[5\]\[11\] memory\[6\]\[11\] memory\[7\]\[11\] _1360_
+ _1361_ VGND VGND VPWR VPWR _1423_ sky130_fd_sc_hd__mux4_1
X_6447_ net1047 _3275_ _3280_ _3285_ VGND VGND VPWR VPWR _0231_ sky130_fd_sc_hd__a31o_1
XFILLER_0_3_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3659_ memory\[28\]\[8\] memory\[29\]\[8\] memory\[30\]\[8\] memory\[31\]\[8\] _1178_
+ _1179_ VGND VGND VPWR VPWR _1357_ sky130_fd_sc_hd__mux4_1
X_6378_ _2849_ _3238_ VGND VGND VPWR VPWR _3245_ sky130_fd_sc_hd__and2_1
X_5329_ _2457_ _2739_ _2741_ net368 VGND VGND VPWR VPWR _0682_ sky130_fd_sc_hd__a22o_1
XFILLER_0_98_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_97_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_66_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_157 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_110_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_22_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_119_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6851__58 clknet_1_0__leaf__3446_ VGND VGND VPWR VPWR net203 sky130_fd_sc_hd__inv_2
XFILLER_0_57_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4700_ memory\[8\]\[26\] memory\[9\]\[26\] memory\[10\]\[26\] memory\[11\]\[26\]
+ _1837_ _1838_ VGND VGND VPWR VPWR _2348_ sky130_fd_sc_hd__mux4_1
XTAP_1191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5680_ _2861_ _2859_ VGND VGND VPWR VPWR _2862_ sky130_fd_sc_hd__and2_1
X_4631_ _2281_ _2282_ _1809_ VGND VGND VPWR VPWR _2283_ sky130_fd_sc_hd__mux2_1
XFILLER_0_72_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_115_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_114_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7350_ clknet_leaf_112_clk _0909_ VGND VGND VPWR VPWR memory\[18\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_4562_ memory\[16\]\[19\] memory\[17\]\[19\] memory\[18\]\[19\] memory\[19\]\[19\]
+ _2028_ _2029_ VGND VGND VPWR VPWR _2217_ sky130_fd_sc_hd__mux4_1
Xhold604 memory\[27\]\[24\] VGND VGND VPWR VPWR net813 sky130_fd_sc_hd__dlygate4sd3_1
X_6301_ _2888_ _3210_ VGND VGND VPWR VPWR _3215_ sky130_fd_sc_hd__and2_1
Xhold615 memory\[1\]\[23\] VGND VGND VPWR VPWR net824 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_69_43 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold626 memory\[13\]\[7\] VGND VGND VPWR VPWR net835 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4493_ memory\[28\]\[15\] memory\[29\]\[15\] memory\[30\]\[15\] memory\[31\]\[15\]
+ _2092_ _2093_ VGND VGND VPWR VPWR _2152_ sky130_fd_sc_hd__mux4_1
X_3513_ _1155_ _1213_ _1215_ _1217_ _1184_ VGND VGND VPWR VPWR _1218_ sky130_fd_sc_hd__a221o_1
X_7281_ clknet_leaf_8_clk _0840_ VGND VGND VPWR VPWR memory\[8\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_52_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold637 memory\[11\]\[21\] VGND VGND VPWR VPWR net846 sky130_fd_sc_hd__dlygate4sd3_1
X_6232_ _2895_ _3167_ VGND VGND VPWR VPWR _3175_ sky130_fd_sc_hd__and2_1
Xhold659 memory\[21\]\[21\] VGND VGND VPWR VPWR net868 sky130_fd_sc_hd__dlygate4sd3_1
Xclkbuf_leaf_6_clk clknet_4_2_0_clk VGND VGND VPWR VPWR clknet_leaf_6_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_12_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold648 memory\[28\]\[15\] VGND VGND VPWR VPWR net857 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6163_ net674 _3130_ _3122_ _3134_ VGND VGND VPWR VPWR _1123_ sky130_fd_sc_hd__a31o_1
XTAP_920 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_931 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_953 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_942 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_986 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_975 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6094_ _3094_ VGND VGND VPWR VPWR _3095_ sky130_fd_sc_hd__clkbuf_4
X_5114_ net44 VGND VGND VPWR VPWR _2621_ sky130_fd_sc_hd__clkbuf_8
XTAP_964 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_997 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5045_ net1138 _2572_ _2573_ VGND VGND VPWR VPWR _2577_ sky130_fd_sc_hd__and3_1
XFILLER_0_26_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_95_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6996_ clknet_leaf_4_clk _0587_ VGND VGND VPWR VPWR memory\[26\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_75_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5947_ net982 _3006_ _3008_ _3011_ VGND VGND VPWR VPWR _1030_ sky130_fd_sc_hd__a31o_1
X_5878_ _2845_ _2965_ VGND VGND VPWR VPWR _2971_ sky130_fd_sc_hd__and2_1
X_7617_ clknet_leaf_99_clk _0151_ VGND VGND VPWR VPWR memory\[27\]\[18\] sky130_fd_sc_hd__dfxtp_1
X_4829_ _2461_ _2449_ _2453_ net1045 VGND VGND VPWR VPWR _0461_ sky130_fd_sc_hd__a22o_1
XFILLER_0_28_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7548_ clknet_leaf_92_clk _1107_ VGND VGND VPWR VPWR memory\[20\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_70_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7479_ clknet_leaf_10_clk _1038_ VGND VGND VPWR VPWR memory\[24\]\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_98_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_86_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_22_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold1 memory\[17\]\[4\] VGND VGND VPWR VPWR net210 sky130_fd_sc_hd__dlygate4sd3_1
X_6781_ _2667_ _3434_ _3435_ net420 VGND VGND VPWR VPWR _0415_ sky130_fd_sc_hd__a22o_1
XFILLER_0_119_318 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_9_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5801_ net1173 _2597_ _2921_ VGND VGND VPWR VPWR _2926_ sky130_fd_sc_hd__and3_1
X_3993_ _1669_ _1671_ _1674_ _1154_ _1606_ VGND VGND VPWR VPWR _1675_ sky130_fd_sc_hd__a221o_1
X_5732_ _2897_ _2882_ VGND VGND VPWR VPWR _2898_ sky130_fd_sc_hd__and2_1
XFILLER_0_45_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_84_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_647 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_115_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_72_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5663_ _2849_ _2836_ VGND VGND VPWR VPWR _2850_ sky130_fd_sc_hd__and2_1
X_7402_ clknet_leaf_30_clk _0961_ VGND VGND VPWR VPWR memory\[25\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_103_708 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4614_ _2097_ _2262_ _2264_ _2266_ _2249_ VGND VGND VPWR VPWR _2267_ sky130_fd_sc_hd__a221o_1
X_5594_ _2636_ _2804_ VGND VGND VPWR VPWR _2807_ sky130_fd_sc_hd__and2_1
X_7333_ clknet_leaf_65_clk _0892_ VGND VGND VPWR VPWR memory\[7\]\[22\] sky130_fd_sc_hd__dfxtp_1
Xhold401 memory\[14\]\[12\] VGND VGND VPWR VPWR net610 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_25_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4545_ _2199_ _2200_ _1903_ VGND VGND VPWR VPWR _2201_ sky130_fd_sc_hd__mux2_1
Xhold412 memory\[21\]\[24\] VGND VGND VPWR VPWR net621 sky130_fd_sc_hd__dlygate4sd3_1
Xhold434 memory\[23\]\[22\] VGND VGND VPWR VPWR net643 sky130_fd_sc_hd__dlygate4sd3_1
Xhold423 memory\[7\]\[6\] VGND VGND VPWR VPWR net632 sky130_fd_sc_hd__dlygate4sd3_1
Xhold445 memory\[27\]\[6\] VGND VGND VPWR VPWR net654 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_52_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7264_ net167 _0008_ VGND VGND VPWR VPWR net90 sky130_fd_sc_hd__dfxtp_2
X_4476_ _2134_ _2135_ _1976_ VGND VGND VPWR VPWR _2136_ sky130_fd_sc_hd__mux2_1
XFILLER_0_13_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold478 memory\[26\]\[5\] VGND VGND VPWR VPWR net687 sky130_fd_sc_hd__dlygate4sd3_1
Xhold467 memory\[30\]\[3\] VGND VGND VPWR VPWR net676 sky130_fd_sc_hd__dlygate4sd3_1
Xhold456 memory\[3\]\[13\] VGND VGND VPWR VPWR net665 sky130_fd_sc_hd__dlygate4sd3_1
X_7195_ clknet_leaf_71_clk _0786_ VGND VGND VPWR VPWR memory\[14\]\[12\] sky130_fd_sc_hd__dfxtp_1
Xhold489 memory\[22\]\[14\] VGND VGND VPWR VPWR net698 sky130_fd_sc_hd__dlygate4sd3_1
X_6215_ _2878_ _3154_ VGND VGND VPWR VPWR _3165_ sky130_fd_sc_hd__and2_1
X_6146_ net809 _3117_ _3122_ _3125_ VGND VGND VPWR VPWR _1115_ sky130_fd_sc_hd__a31o_1
XTAP_750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_783 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_772 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_794 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6077_ _2893_ _3079_ VGND VGND VPWR VPWR _3085_ sky130_fd_sc_hd__and2_1
X_6830__39 clknet_1_0__leaf__2787_ VGND VGND VPWR VPWR net184 sky130_fd_sc_hd__inv_2
X_5028_ net1127 _2557_ _2560_ VGND VGND VPWR VPWR _2567_ sky130_fd_sc_hd__and3_1
X_6979_ clknet_leaf_63_clk _0570_ VGND VGND VPWR VPWR memory\[6\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_91_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_63_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_8_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7430__122 VGND VGND VPWR VPWR _7430__122/HI net122 sky130_fd_sc_hd__conb_1
XFILLER_0_98_352 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_59_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_27_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4330_ memory\[8\]\[7\] memory\[9\]\[7\] memory\[10\]\[7\] memory\[11\]\[7\] _1948_
+ _1949_ VGND VGND VPWR VPWR _1997_ sky130_fd_sc_hd__mux4_1
XFILLER_0_22_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_25 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4261_ _1929_ _1930_ _1869_ VGND VGND VPWR VPWR _1931_ sky130_fd_sc_hd__mux2_1
X_6000_ _2891_ _3036_ VGND VGND VPWR VPWR _3041_ sky130_fd_sc_hd__and2_1
XFILLER_0_5_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4192_ memory\[4\]\[1\] memory\[5\]\[1\] memory\[6\]\[1\] memory\[7\]\[1\] _1863_
+ _1864_ VGND VGND VPWR VPWR _1865_ sky130_fd_sc_hd__mux4_1
X_7882_ clknet_leaf_52_clk _0416_ VGND VGND VPWR VPWR memory\[13\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_82_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6902_ clknet_leaf_22_clk _0493_ VGND VGND VPWR VPWR memory\[15\]\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_106_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3976_ _1650_ _1658_ VGND VGND VPWR VPWR _1659_ sky130_fd_sc_hd__and2_1
X_6764_ _2634_ _3432_ _3433_ net726 VGND VGND VPWR VPWR _0400_ sky130_fd_sc_hd__a22o_1
XFILLER_0_64_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5715_ net30 VGND VGND VPWR VPWR _2886_ sky130_fd_sc_hd__buf_4
X_6695_ net47 _3388_ VGND VGND VPWR VPWR _3399_ sky130_fd_sc_hd__and2_1
XFILLER_0_45_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_115_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5646_ net27 VGND VGND VPWR VPWR _2838_ sky130_fd_sc_hd__buf_4
XFILLER_0_5_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_103_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold220 memory\[30\]\[1\] VGND VGND VPWR VPWR net429 sky130_fd_sc_hd__dlygate4sd3_1
X_5577_ _2619_ _2791_ VGND VGND VPWR VPWR _2797_ sky130_fd_sc_hd__and2_1
Xhold253 memory\[7\]\[28\] VGND VGND VPWR VPWR net462 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold231 memory\[17\]\[5\] VGND VGND VPWR VPWR net440 sky130_fd_sc_hd__dlygate4sd3_1
X_4528_ memory\[20\]\[17\] memory\[21\]\[17\] memory\[22\]\[17\] memory\[23\]\[17\]
+ _1831_ _1833_ VGND VGND VPWR VPWR _2185_ sky130_fd_sc_hd__mux4_1
X_7316_ clknet_leaf_106_clk _0875_ VGND VGND VPWR VPWR memory\[7\]\[5\] sky130_fd_sc_hd__dfxtp_1
Xhold242 memory\[29\]\[15\] VGND VGND VPWR VPWR net451 sky130_fd_sc_hd__dlygate4sd3_1
Xhold264 memory\[30\]\[20\] VGND VGND VPWR VPWR net473 sky130_fd_sc_hd__dlygate4sd3_1
Xhold286 memory\[19\]\[25\] VGND VGND VPWR VPWR net495 sky130_fd_sc_hd__dlygate4sd3_1
Xhold275 memory\[30\]\[15\] VGND VGND VPWR VPWR net484 sky130_fd_sc_hd__dlygate4sd3_1
X_4459_ _2086_ _2112_ _2115_ _2119_ _2038_ VGND VGND VPWR VPWR _2120_ sky130_fd_sc_hd__a221o_1
XFILLER_0_40_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7247_ net150 _0000_ VGND VGND VPWR VPWR net82 sky130_fd_sc_hd__dfxtp_2
Xhold297 memory\[21\]\[9\] VGND VGND VPWR VPWR net506 sky130_fd_sc_hd__dlygate4sd3_1
X_7178_ clknet_leaf_60_clk _0769_ VGND VGND VPWR VPWR memory\[2\]\[27\] sky130_fd_sc_hd__dfxtp_1
X_6129_ net912 _3104_ _3109_ _3115_ VGND VGND VPWR VPWR _1108_ sky130_fd_sc_hd__a31o_1
XTAP_580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_115 _2555_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_104 _1938_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_1724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_126 _2888_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_148 _1959_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_137 _3369_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_1757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1779 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1768 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_119_693 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_91_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_36_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_1__f__2787_ clknet_0__2787_ VGND VGND VPWR VPWR clknet_1_1__leaf__2787_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_86_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3830_ memory\[0\]\[16\] memory\[1\]\[16\] memory\[2\]\[16\] memory\[3\]\[16\] _1363_
+ _1364_ VGND VGND VPWR VPWR _1520_ sky130_fd_sc_hd__mux4_1
XFILLER_0_6_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3761_ memory\[16\]\[13\] memory\[17\]\[13\] memory\[18\]\[13\] memory\[19\]\[13\]
+ _1349_ _1350_ VGND VGND VPWR VPWR _1454_ sky130_fd_sc_hd__mux4_1
XFILLER_0_27_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5500_ _2775_ VGND VGND VPWR VPWR _2779_ sky130_fd_sc_hd__buf_4
X_6480_ net908 _3291_ _3294_ _3303_ VGND VGND VPWR VPWR _0246_ sky130_fd_sc_hd__a31o_1
XFILLER_0_42_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3692_ _1380_ _1388_ VGND VGND VPWR VPWR _1389_ sky130_fd_sc_hd__and2_1
X_5431_ _2759_ VGND VGND VPWR VPWR _2764_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_112_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5362_ _2746_ _2442_ _2490_ VGND VGND VPWR VPWR _2747_ sky130_fd_sc_hd__and3_1
X_4313_ _1829_ _1980_ VGND VGND VPWR VPWR _1981_ sky130_fd_sc_hd__or2_1
XFILLER_0_10_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7101_ clknet_leaf_78_clk _0692_ VGND VGND VPWR VPWR memory\[29\]\[14\] sky130_fd_sc_hd__dfxtp_1
X_5293_ _2654_ _2721_ VGND VGND VPWR VPWR _2722_ sky130_fd_sc_hd__and2_1
XFILLER_0_77_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7032_ clknet_leaf_105_clk _0623_ VGND VGND VPWR VPWR memory\[16\]\[9\] sky130_fd_sc_hd__dfxtp_1
X_4244_ memory\[8\]\[3\] memory\[9\]\[3\] memory\[10\]\[3\] memory\[11\]\[3\] _1913_
+ _1914_ VGND VGND VPWR VPWR _1915_ sky130_fd_sc_hd__mux4_1
XFILLER_0_93_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4175_ _1844_ _1847_ _1848_ VGND VGND VPWR VPWR _1849_ sky130_fd_sc_hd__mux2_1
XTAP_1009 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7934_ net197 _0038_ VGND VGND VPWR VPWR net56 sky130_fd_sc_hd__dfxtp_1
X_7865_ clknet_leaf_72_clk _0399_ VGND VGND VPWR VPWR memory\[13\]\[10\] sky130_fd_sc_hd__dfxtp_1
X_6816_ _2654_ _3443_ _3444_ net1071 VGND VGND VPWR VPWR _0441_ sky130_fd_sc_hd__a22o_1
XFILLER_0_65_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7796_ clknet_leaf_20_clk _0330_ VGND VGND VPWR VPWR memory\[12\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_9_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6747_ _3427_ VGND VGND VPWR VPWR _3428_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_9_154 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3959_ _1642_ VGND VGND VPWR VPWR _0014_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_61_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6678_ net27 _3388_ VGND VGND VPWR VPWR _3390_ sky130_fd_sc_hd__and2_1
XFILLER_0_33_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5629_ net559 _2824_ _2816_ _2826_ VGND VGND VPWR VPWR _0865_ sky130_fd_sc_hd__a31o_1
XFILLER_0_60_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7420__132 VGND VGND VPWR VPWR _7420__132/HI net132 sky130_fd_sc_hd__conb_1
XTAP_1532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_107_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_51_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_122_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_99_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5980_ net853 _3021_ _3022_ _3029_ VGND VGND VPWR VPWR _1045_ sky130_fd_sc_hd__a31o_1
X_4931_ _2507_ VGND VGND VPWR VPWR _2508_ sky130_fd_sc_hd__buf_4
XFILLER_0_59_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4862_ net31 VGND VGND VPWR VPWR _2480_ sky130_fd_sc_hd__buf_4
X_7650_ clknet_leaf_98_clk _0184_ VGND VGND VPWR VPWR memory\[19\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_117_416 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6601_ _2623_ _3368_ _3370_ net626 VGND VGND VPWR VPWR _0300_ sky130_fd_sc_hd__a22o_1
X_3813_ memory\[4\]\[15\] memory\[5\]\[15\] memory\[6\]\[15\] memory\[7\]\[15\] _1199_
+ _1200_ VGND VGND VPWR VPWR _1504_ sky130_fd_sc_hd__mux4_1
XFILLER_0_117_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_26 _2323_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4793_ _2434_ _2435_ _1976_ VGND VGND VPWR VPWR _2436_ sky130_fd_sc_hd__mux2_1
XANTENNA_15 _1812_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7581_ clknet_leaf_109_clk _1140_ VGND VGND VPWR VPWR memory\[23\]\[14\] sky130_fd_sc_hd__dfxtp_1
XANTENNA_48 _2909_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_37 _2682_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_59 _3096_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6532_ net573 _3333_ _3324_ _3334_ VGND VGND VPWR VPWR _0267_ sky130_fd_sc_hd__a31o_1
X_3744_ _1436_ _1437_ _1279_ VGND VGND VPWR VPWR _1438_ sky130_fd_sc_hd__mux2_1
XFILLER_0_15_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3675_ _1372_ VGND VGND VPWR VPWR _0030_ sky130_fd_sc_hd__clkbuf_1
X_6463_ _3279_ VGND VGND VPWR VPWR _3294_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_112_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput100 net100 VGND VGND VPWR VPWR data_out2[26] sky130_fd_sc_hd__buf_2
X_5414_ _2459_ _2758_ _2760_ net242 VGND VGND VPWR VPWR _0748_ sky130_fd_sc_hd__a22o_1
Xoutput111 net111 VGND VGND VPWR VPWR data_out2[7] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_2_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6394_ net720 _3249_ _3250_ _3254_ VGND VGND VPWR VPWR _0209_ sky130_fd_sc_hd__a31o_1
XFILLER_0_100_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6857__64 clknet_1_0__leaf__3446_ VGND VGND VPWR VPWR net209 sky130_fd_sc_hd__inv_2
X_5345_ _2473_ _2742_ _2743_ net614 VGND VGND VPWR VPWR _0696_ sky130_fd_sc_hd__a22o_1
XFILLER_0_11_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5276_ _2638_ _2708_ VGND VGND VPWR VPWR _2712_ sky130_fd_sc_hd__and2_1
X_7015_ clknet_leaf_30_clk _0606_ VGND VGND VPWR VPWR memory\[26\]\[24\] sky130_fd_sc_hd__dfxtp_1
X_4227_ _1862_ _1894_ _1896_ _1898_ _1851_ VGND VGND VPWR VPWR _1899_ sky130_fd_sc_hd__a221o_1
X_4158_ net2 VGND VGND VPWR VPWR _1832_ sky130_fd_sc_hd__buf_4
X_4089_ memory\[24\]\[30\] memory\[25\]\[30\] memory\[26\]\[30\] memory\[27\]\[30\]
+ _1251_ _1252_ VGND VGND VPWR VPWR _1765_ sky130_fd_sc_hd__mux4_1
X_7917_ clknet_leaf_40_clk _0451_ VGND VGND VPWR VPWR memory\[17\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_77_174 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_77_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7848_ clknet_leaf_38_clk _0382_ VGND VGND VPWR VPWR memory\[9\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_77_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7779_ clknet_leaf_36_clk _0313_ VGND VGND VPWR VPWR memory\[30\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_92_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_104_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_103_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_103_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_108_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_33_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_84_612 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_1373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput13 data_addr[2] VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__clkbuf_2
Xinput35 data_in[27] VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__clkbuf_2
Xinput24 data_in[17] VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__clkbuf_4
Xinput46 data_in[8] VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__buf_2
XFILLER_0_64_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_12_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold808 memory\[4\]\[7\] VGND VGND VPWR VPWR net1017 sky130_fd_sc_hd__dlygate4sd3_1
Xhold819 memory\[2\]\[5\] VGND VGND VPWR VPWR net1028 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_52_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3460_ _1165_ VGND VGND VPWR VPWR _1166_ sky130_fd_sc_hd__buf_8
XFILLER_0_110_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_58_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5130_ _2631_ _2632_ VGND VGND VPWR VPWR _2633_ sky130_fd_sc_hd__and2_1
X_5061_ _2559_ VGND VGND VPWR VPWR _2586_ sky130_fd_sc_hd__buf_2
XFILLER_0_42_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4012_ _1684_ _1692_ VGND VGND VPWR VPWR _1693_ sky130_fd_sc_hd__and2_1
X_5963_ net331 _3006_ _3008_ _3019_ VGND VGND VPWR VPWR _1038_ sky130_fd_sc_hd__a31o_1
X_4914_ _2479_ _2499_ _2500_ net227 VGND VGND VPWR VPWR _0507_ sky130_fd_sc_hd__a22o_1
X_7702_ clknet_leaf_108_clk _0236_ VGND VGND VPWR VPWR memory\[5\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_74_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_59_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5894_ _2861_ _2978_ VGND VGND VPWR VPWR _2980_ sky130_fd_sc_hd__and2_1
X_7410__142 VGND VGND VPWR VPWR _7410__142/HI net142 sky130_fd_sc_hd__conb_1
XFILLER_0_118_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_7633_ clknet_leaf_116_clk _0167_ VGND VGND VPWR VPWR memory\[19\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_4845_ _2470_ _2464_ _2465_ net857 VGND VGND VPWR VPWR _0468_ sky130_fd_sc_hd__a22o_1
XFILLER_0_28_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4776_ _1850_ _2415_ _2417_ _2419_ net5 VGND VGND VPWR VPWR _2420_ sky130_fd_sc_hd__a221o_1
X_7564_ clknet_leaf_24_clk _1123_ VGND VGND VPWR VPWR memory\[20\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_74_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6515_ _3323_ VGND VGND VPWR VPWR _3324_ sky130_fd_sc_hd__clkbuf_4
X_3727_ _1390_ _1417_ _1419_ _1421_ _1403_ VGND VGND VPWR VPWR _1422_ sky130_fd_sc_hd__a221o_1
X_7495_ clknet_leaf_29_clk _1054_ VGND VGND VPWR VPWR memory\[24\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_15_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6446_ _2840_ _3282_ VGND VGND VPWR VPWR _3285_ sky130_fd_sc_hd__and2_1
X_3658_ _1169_ _1355_ VGND VGND VPWR VPWR _1356_ sky130_fd_sc_hd__or2_1
X_3589_ memory\[12\]\[4\] memory\[13\]\[4\] memory\[14\]\[4\] memory\[15\]\[4\] _1251_
+ _1252_ VGND VGND VPWR VPWR _1291_ sky130_fd_sc_hd__mux4_1
X_6377_ net526 _3233_ _3236_ _3244_ VGND VGND VPWR VPWR _0202_ sky130_fd_sc_hd__a31o_1
XFILLER_0_2_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5328_ _2456_ _2739_ _2741_ net228 VGND VGND VPWR VPWR _0681_ sky130_fd_sc_hd__a22o_1
Xclkbuf_4_5_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_5_0_clk sky130_fd_sc_hd__clkbuf_8
X_5259_ _2621_ _2695_ VGND VGND VPWR VPWR _2702_ sky130_fd_sc_hd__and2_1
XFILLER_0_97_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_65_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_119_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_28_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4630_ memory\[0\]\[22\] memory\[1\]\[22\] memory\[2\]\[22\] memory\[3\]\[22\] _1845_
+ _1846_ VGND VGND VPWR VPWR _2282_ sky130_fd_sc_hd__mux4_1
XFILLER_0_114_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6300_ net1064 _3213_ _3209_ _3214_ VGND VGND VPWR VPWR _0155_ sky130_fd_sc_hd__a31o_1
X_4561_ memory\[20\]\[19\] memory\[21\]\[19\] memory\[22\]\[19\] memory\[23\]\[19\]
+ _1938_ _1939_ VGND VGND VPWR VPWR _2216_ sky130_fd_sc_hd__mux4_1
XFILLER_0_40_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7280_ clknet_leaf_15_clk _0839_ VGND VGND VPWR VPWR memory\[8\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_69_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold627 memory\[19\]\[15\] VGND VGND VPWR VPWR net836 sky130_fd_sc_hd__dlygate4sd3_1
Xhold616 memory\[18\]\[2\] VGND VGND VPWR VPWR net825 sky130_fd_sc_hd__dlygate4sd3_1
X_4492_ _2113_ _2150_ VGND VGND VPWR VPWR _2151_ sky130_fd_sc_hd__or2_1
XFILLER_0_25_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold605 memory\[4\]\[16\] VGND VGND VPWR VPWR net814 sky130_fd_sc_hd__dlygate4sd3_1
X_3512_ _1177_ _1216_ _1181_ VGND VGND VPWR VPWR _1217_ sky130_fd_sc_hd__o21a_1
XFILLER_0_100_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6231_ net981 _3172_ _3166_ _3174_ VGND VGND VPWR VPWR _1151_ sky130_fd_sc_hd__a31o_1
Xhold649 memory\[24\]\[5\] VGND VGND VPWR VPWR net858 sky130_fd_sc_hd__dlygate4sd3_1
Xhold638 memory\[7\]\[13\] VGND VGND VPWR VPWR net847 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_122_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6162_ _2901_ _3123_ VGND VGND VPWR VPWR _3134_ sky130_fd_sc_hd__and2_1
XFILLER_0_40_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_910 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_110_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5113_ net687 _2601_ _2606_ _2620_ VGND VGND VPWR VPWR _0587_ sky130_fd_sc_hd__a31o_1
XTAP_921 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_932 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_943 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6093_ _2691_ _3093_ VGND VGND VPWR VPWR _3094_ sky130_fd_sc_hd__nand2_8
XTAP_987 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_976 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_965 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_954 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_109_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_85_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_998 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5044_ _2467_ _2571_ _2576_ VGND VGND VPWR VPWR _0562_ sky130_fd_sc_hd__a21o_1
XFILLER_0_79_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_67_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6995_ clknet_leaf_0_clk _0586_ VGND VGND VPWR VPWR memory\[26\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_5946_ _2834_ _3010_ VGND VGND VPWR VPWR _3011_ sky130_fd_sc_hd__and2_1
XFILLER_0_48_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5877_ net777 _2968_ _2963_ _2970_ VGND VGND VPWR VPWR _1001_ sky130_fd_sc_hd__a31o_1
X_7616_ clknet_leaf_100_clk _0150_ VGND VGND VPWR VPWR memory\[27\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_47_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4828_ net46 VGND VGND VPWR VPWR _2461_ sky130_fd_sc_hd__buf_4
XFILLER_0_90_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_121_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4759_ _2395_ _2403_ VGND VGND VPWR VPWR _2404_ sky130_fd_sc_hd__and2_1
X_7547_ clknet_leaf_93_clk _1106_ VGND VGND VPWR VPWR memory\[20\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_16_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7478_ clknet_leaf_1_clk _1037_ VGND VGND VPWR VPWR memory\[24\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_6429_ net1014 _3262_ _3263_ _3273_ VGND VGND VPWR VPWR _0225_ sky130_fd_sc_hd__a31o_1
XFILLER_0_101_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_34_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold2 memory\[28\]\[2\] VGND VGND VPWR VPWR net211 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_55_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6780_ _2665_ _3434_ _3435_ net303 VGND VGND VPWR VPWR _0414_ sky130_fd_sc_hd__a22o_1
X_3992_ _1672_ _1673_ _1166_ VGND VGND VPWR VPWR _1674_ sky130_fd_sc_hd__mux2_1
X_5800_ _2456_ _2919_ _2925_ VGND VGND VPWR VPWR _0937_ sky130_fd_sc_hd__a21o_1
X_5731_ net35 VGND VGND VPWR VPWR _2897_ sky130_fd_sc_hd__buf_4
XFILLER_0_57_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5662_ net44 VGND VGND VPWR VPWR _2849_ sky130_fd_sc_hd__clkbuf_4
X_7401_ clknet_leaf_31_clk _0960_ VGND VGND VPWR VPWR memory\[25\]\[26\] sky130_fd_sc_hd__dfxtp_1
X_4613_ _2104_ _2265_ _2106_ VGND VGND VPWR VPWR _2266_ sky130_fd_sc_hd__o21a_1
X_5593_ net1024 _2798_ _2803_ _2806_ VGND VGND VPWR VPWR _0849_ sky130_fd_sc_hd__a31o_1
XFILLER_0_32_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_115_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold402 memory\[8\]\[26\] VGND VGND VPWR VPWR net611 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_111_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7332_ clknet_leaf_65_clk _0891_ VGND VGND VPWR VPWR memory\[7\]\[21\] sky130_fd_sc_hd__dfxtp_1
X_4544_ memory\[16\]\[18\] memory\[17\]\[18\] memory\[18\]\[18\] memory\[19\]\[18\]
+ _2028_ _2029_ VGND VGND VPWR VPWR _2200_ sky130_fd_sc_hd__mux4_1
Xhold424 memory\[1\]\[28\] VGND VGND VPWR VPWR net633 sky130_fd_sc_hd__dlygate4sd3_1
Xhold435 memory\[12\]\[15\] VGND VGND VPWR VPWR net644 sky130_fd_sc_hd__dlygate4sd3_1
X_7263_ net166 _0007_ VGND VGND VPWR VPWR net89 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_13_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold413 memory\[19\]\[13\] VGND VGND VPWR VPWR net622 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_20_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold457 memory\[30\]\[28\] VGND VGND VPWR VPWR net666 sky130_fd_sc_hd__dlygate4sd3_1
Xhold468 memory\[22\]\[25\] VGND VGND VPWR VPWR net677 sky130_fd_sc_hd__dlygate4sd3_1
X_4475_ memory\[16\]\[14\] memory\[17\]\[14\] memory\[18\]\[14\] memory\[19\]\[14\]
+ _1970_ _1971_ VGND VGND VPWR VPWR _2135_ sky130_fd_sc_hd__mux4_1
Xhold446 memory\[20\]\[2\] VGND VGND VPWR VPWR net655 sky130_fd_sc_hd__dlygate4sd3_1
X_6214_ net909 _3159_ _3153_ _3164_ VGND VGND VPWR VPWR _1144_ sky130_fd_sc_hd__a31o_1
Xhold479 memory\[5\]\[30\] VGND VGND VPWR VPWR net688 sky130_fd_sc_hd__dlygate4sd3_1
X_7194_ clknet_leaf_70_clk _0785_ VGND VGND VPWR VPWR memory\[14\]\[11\] sky130_fd_sc_hd__dfxtp_1
X_6145_ _2884_ _3123_ VGND VGND VPWR VPWR _3125_ sky130_fd_sc_hd__and2_1
XFILLER_0_96_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6076_ net578 _3075_ _3078_ _3084_ VGND VGND VPWR VPWR _1086_ sky130_fd_sc_hd__a31o_1
XTAP_762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_784 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_773 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_795 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5027_ _2458_ _2556_ _2566_ VGND VGND VPWR VPWR _0555_ sky130_fd_sc_hd__a21o_1
XFILLER_0_67_206 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_95_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6978_ clknet_leaf_82_clk _0569_ VGND VGND VPWR VPWR memory\[6\]\[19\] sky130_fd_sc_hd__dfxtp_1
X_5929_ net694 _2994_ _2990_ _2999_ VGND VGND VPWR VPWR _1024_ sky130_fd_sc_hd__a31o_1
XFILLER_0_75_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_50_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_116_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_98_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_509 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_27_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_81_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4260_ memory\[0\]\[4\] memory\[1\]\[4\] memory\[2\]\[4\] memory\[3\]\[4\] _1866_
+ _1867_ VGND VGND VPWR VPWR _1930_ sky130_fd_sc_hd__mux4_1
XFILLER_0_5_37 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4191_ _1801_ VGND VGND VPWR VPWR _1864_ sky130_fd_sc_hd__buf_4
XFILLER_0_89_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7950_ net149 _0056_ VGND VGND VPWR VPWR net74 sky130_fd_sc_hd__dfxtp_2
X_7881_ clknet_leaf_54_clk _0415_ VGND VGND VPWR VPWR memory\[13\]\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_89_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6901_ clknet_leaf_20_clk _0492_ VGND VGND VPWR VPWR memory\[15\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_10_7 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3975_ _1479_ _1653_ _1655_ _1657_ _1606_ VGND VGND VPWR VPWR _1658_ sky130_fd_sc_hd__a221o_1
X_6763_ _2631_ _3432_ _3433_ net681 VGND VGND VPWR VPWR _0399_ sky130_fd_sc_hd__a22o_1
XFILLER_0_17_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5714_ net689 _2867_ _2880_ _2885_ VGND VGND VPWR VPWR _0891_ sky130_fd_sc_hd__a31o_1
X_6694_ net743 _3393_ _3386_ _3398_ VGND VGND VPWR VPWR _0365_ sky130_fd_sc_hd__a31o_1
XFILLER_0_115_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5645_ net818 _2824_ _2833_ _2837_ VGND VGND VPWR VPWR _0870_ sky130_fd_sc_hd__a31o_1
XFILLER_0_86_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold210 memory\[11\]\[26\] VGND VGND VPWR VPWR net419 sky130_fd_sc_hd__dlygate4sd3_1
X_5576_ net1031 _2731_ _2789_ _2796_ VGND VGND VPWR VPWR _0842_ sky130_fd_sc_hd__a31o_1
Xhold232 memory\[12\]\[26\] VGND VGND VPWR VPWR net441 sky130_fd_sc_hd__dlygate4sd3_1
Xhold243 memory\[14\]\[16\] VGND VGND VPWR VPWR net452 sky130_fd_sc_hd__dlygate4sd3_1
X_7315_ clknet_leaf_108_clk _0874_ VGND VGND VPWR VPWR memory\[7\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_40_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4527_ _1964_ _2183_ _1968_ VGND VGND VPWR VPWR _2184_ sky130_fd_sc_hd__o21a_1
Xhold221 memory\[3\]\[8\] VGND VGND VPWR VPWR net430 sky130_fd_sc_hd__dlygate4sd3_1
Xhold254 memory\[8\]\[21\] VGND VGND VPWR VPWR net463 sky130_fd_sc_hd__dlygate4sd3_1
X_7246_ clknet_leaf_19_clk _0837_ VGND VGND VPWR VPWR memory\[31\]\[31\] sky130_fd_sc_hd__dfxtp_1
Xhold265 memory\[13\]\[15\] VGND VGND VPWR VPWR net474 sky130_fd_sc_hd__dlygate4sd3_1
X_4458_ _2116_ _2117_ _2118_ VGND VGND VPWR VPWR _2119_ sky130_fd_sc_hd__o21a_1
Xhold287 memory\[4\]\[12\] VGND VGND VPWR VPWR net496 sky130_fd_sc_hd__dlygate4sd3_1
Xhold276 memory\[3\]\[10\] VGND VGND VPWR VPWR net485 sky130_fd_sc_hd__dlygate4sd3_1
X_7177_ clknet_leaf_56_clk _0768_ VGND VGND VPWR VPWR memory\[2\]\[26\] sky130_fd_sc_hd__dfxtp_1
Xhold298 memory\[26\]\[8\] VGND VGND VPWR VPWR net507 sky130_fd_sc_hd__dlygate4sd3_1
X_6128_ _2868_ _3110_ VGND VGND VPWR VPWR _3115_ sky130_fd_sc_hd__and2_1
X_4389_ _2051_ _2052_ _1903_ VGND VGND VPWR VPWR _2053_ sky130_fd_sc_hd__mux2_1
XTAP_570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6059_ net571 _3062_ _3065_ _3074_ VGND VGND VPWR VPWR _1079_ sky130_fd_sc_hd__a31o_1
XANTENNA_105 _1960_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_116 _2861_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_1725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_127 _2888_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_138 _3439_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_149 _2086_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_1758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1769 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_8_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5542__18 clknet_1_0__leaf__2785_ VGND VGND VPWR VPWR net163 sky130_fd_sc_hd__inv_2
XFILLER_0_36_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_1__f__2786_ clknet_0__2786_ VGND VGND VPWR VPWR clknet_1_1__leaf__2786_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_36_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_86_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_74_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3760_ memory\[20\]\[13\] memory\[21\]\[13\] memory\[22\]\[13\] memory\[23\]\[13\]
+ _1312_ _1313_ VGND VGND VPWR VPWR _1453_ sky130_fd_sc_hd__mux4_1
XFILLER_0_39_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_540 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_15_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5430_ _2757_ VGND VGND VPWR VPWR _2763_ sky130_fd_sc_hd__clkbuf_4
X_3691_ _1382_ _1384_ _1387_ _1207_ _1208_ VGND VGND VPWR VPWR _1388_ sky130_fd_sc_hd__a221o_1
XFILLER_0_14_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5361_ _2443_ _2444_ _2445_ VGND VGND VPWR VPWR _2746_ sky130_fd_sc_hd__nor3_1
XFILLER_0_23_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_684 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_50_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5292_ _2694_ VGND VGND VPWR VPWR _2721_ sky130_fd_sc_hd__clkbuf_4
X_4312_ memory\[8\]\[6\] memory\[9\]\[6\] memory\[10\]\[6\] memory\[11\]\[6\] _1948_
+ _1949_ VGND VGND VPWR VPWR _1980_ sky130_fd_sc_hd__mux4_1
XFILLER_0_2_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_7100_ clknet_leaf_86_clk _0691_ VGND VGND VPWR VPWR memory\[29\]\[13\] sky130_fd_sc_hd__dfxtp_1
X_4243_ _1832_ VGND VGND VPWR VPWR _1914_ sky130_fd_sc_hd__buf_4
X_7031_ clknet_leaf_105_clk _0622_ VGND VGND VPWR VPWR memory\[16\]\[8\] sky130_fd_sc_hd__dfxtp_1
X_4174_ _1808_ VGND VGND VPWR VPWR _1848_ sky130_fd_sc_hd__buf_6
XFILLER_0_93_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7933_ net196 _0037_ VGND VGND VPWR VPWR net55 sky130_fd_sc_hd__dfxtp_2
X_7864_ clknet_leaf_23_clk _0398_ VGND VGND VPWR VPWR memory\[13\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_77_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6815_ _3439_ VGND VGND VPWR VPWR _3444_ sky130_fd_sc_hd__buf_4
XFILLER_0_65_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7795_ clknet_leaf_21_clk _0329_ VGND VGND VPWR VPWR memory\[12\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_9_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6746_ _2442_ _2491_ _2736_ VGND VGND VPWR VPWR _3427_ sky130_fd_sc_hd__and3_1
XFILLER_0_9_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3958_ _1633_ _1641_ VGND VGND VPWR VPWR _1642_ sky130_fd_sc_hd__and2_1
X_3889_ memory\[0\]\[19\] memory\[1\]\[19\] memory\[2\]\[19\] memory\[3\]\[19\] _1363_
+ _1364_ VGND VGND VPWR VPWR _1576_ sky130_fd_sc_hd__mux4_1
XFILLER_0_45_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6677_ net1066 _3359_ _3386_ _3389_ VGND VGND VPWR VPWR _0357_ sky130_fd_sc_hd__a31o_1
XFILLER_0_116_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5628_ _2669_ _2817_ VGND VGND VPWR VPWR _2826_ sky130_fd_sc_hd__and2_1
X_7229_ clknet_leaf_78_clk _0820_ VGND VGND VPWR VPWR memory\[31\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_87_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_507 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_122_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_51_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_122_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_20_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_301 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4930_ _2506_ VGND VGND VPWR VPWR _2507_ sky130_fd_sc_hd__clkbuf_2
X_4861_ _2479_ _2476_ _2477_ net509 VGND VGND VPWR VPWR _0475_ sky130_fd_sc_hd__a22o_1
XFILLER_0_47_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_86_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3812_ _1193_ _1502_ _1197_ VGND VGND VPWR VPWR _1503_ sky130_fd_sc_hd__o21a_1
X_6600_ _2621_ _3368_ _3370_ net318 VGND VGND VPWR VPWR _0299_ sky130_fd_sc_hd__a22o_1
XFILLER_0_117_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_27 _2452_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4792_ memory\[0\]\[31\] memory\[1\]\[31\] memory\[2\]\[31\] memory\[3\]\[31\] _1960_
+ _1961_ VGND VGND VPWR VPWR _2435_ sky130_fd_sc_hd__mux4_1
XFILLER_0_55_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7580_ clknet_leaf_94_clk _1139_ VGND VGND VPWR VPWR memory\[23\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_27_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_38 _2684_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_16 _1828_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3743_ memory\[16\]\[12\] memory\[17\]\[12\] memory\[18\]\[12\] memory\[19\]\[12\]
+ _1349_ _1350_ VGND VGND VPWR VPWR _1437_ sky130_fd_sc_hd__mux4_1
X_6531_ _2849_ _3326_ VGND VGND VPWR VPWR _3334_ sky130_fd_sc_hd__and2_1
XANTENNA_49 _2911_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6462_ net494 _3291_ _3280_ _3293_ VGND VGND VPWR VPWR _0238_ sky130_fd_sc_hd__a31o_1
X_3674_ _1359_ _1371_ VGND VGND VPWR VPWR _1372_ sky130_fd_sc_hd__and2_1
Xoutput101 net101 VGND VGND VPWR VPWR data_out2[27] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_70_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6393_ _2863_ _3251_ VGND VGND VPWR VPWR _3254_ sky130_fd_sc_hd__and2_1
X_5413_ _2458_ _2758_ _2760_ net1028 VGND VGND VPWR VPWR _0747_ sky130_fd_sc_hd__a22o_1
Xoutput112 net112 VGND VGND VPWR VPWR data_out2[8] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_23_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5344_ _2472_ _2742_ _2743_ net238 VGND VGND VPWR VPWR _0695_ sky130_fd_sc_hd__a22o_1
X_5275_ net496 _2704_ _2707_ _2711_ VGND VGND VPWR VPWR _0658_ sky130_fd_sc_hd__a31o_1
X_7014_ clknet_leaf_32_clk _0605_ VGND VGND VPWR VPWR memory\[26\]\[23\] sky130_fd_sc_hd__dfxtp_1
X_4226_ _1876_ _1897_ _1880_ VGND VGND VPWR VPWR _1898_ sky130_fd_sc_hd__o21a_1
XFILLER_0_10_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4157_ _1830_ VGND VGND VPWR VPWR _1831_ sky130_fd_sc_hd__buf_6
XFILLER_0_97_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4088_ _1762_ _1763_ _1176_ VGND VGND VPWR VPWR _1764_ sky130_fd_sc_hd__mux2_1
X_7916_ clknet_leaf_33_clk _0450_ VGND VGND VPWR VPWR memory\[17\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_78_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7847_ clknet_leaf_51_clk _0381_ VGND VGND VPWR VPWR memory\[9\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_53_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_108_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_19_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_108_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7778_ clknet_leaf_85_clk _0312_ VGND VGND VPWR VPWR memory\[30\]\[19\] sky130_fd_sc_hd__dfxtp_1
X_6729_ net807 _3406_ _3413_ _3418_ VGND VGND VPWR VPWR _0380_ sky130_fd_sc_hd__a31o_1
XFILLER_0_92_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_543 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_6_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_112_clk clknet_4_1_0_clk VGND VGND VPWR VPWR clknet_leaf_112_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_104_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_1341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput36 data_in[28] VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__clkbuf_2
Xinput25 data_in[18] VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__clkbuf_4
Xclkbuf_leaf_103_clk clknet_4_3_0_clk VGND VGND VPWR VPWR clknet_leaf_103_clk sky130_fd_sc_hd__clkbuf_16
Xinput14 data_addr[3] VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__buf_2
Xinput47 data_in[9] VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__buf_2
Xhold809 memory\[7\]\[26\] VGND VGND VPWR VPWR net1018 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_52_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_110_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5060_ _2529_ VGND VGND VPWR VPWR _2585_ sky130_fd_sc_hd__buf_2
X_4011_ _1479_ _1687_ _1689_ _1691_ _1606_ VGND VGND VPWR VPWR _1692_ sky130_fd_sc_hd__a221o_1
X_5962_ _2853_ _3010_ VGND VGND VPWR VPWR _3019_ sky130_fd_sc_hd__and2_1
X_4913_ _2478_ _2499_ _2500_ net376 VGND VGND VPWR VPWR _0506_ sky130_fd_sc_hd__a22o_1
X_7701_ clknet_leaf_107_clk _0235_ VGND VGND VPWR VPWR memory\[5\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_47_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5893_ net257 _2968_ _2977_ _2979_ VGND VGND VPWR VPWR _1008_ sky130_fd_sc_hd__a31o_1
XFILLER_0_117_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7632_ clknet_leaf_116_clk _0166_ VGND VGND VPWR VPWR memory\[19\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_23_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4844_ net22 VGND VGND VPWR VPWR _2470_ sky130_fd_sc_hd__buf_4
X_4775_ _1964_ _2418_ _1968_ VGND VGND VPWR VPWR _2419_ sky130_fd_sc_hd__o21a_1
X_7563_ clknet_leaf_25_clk _1122_ VGND VGND VPWR VPWR memory\[20\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_62_318 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_7_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_23_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6514_ _3322_ VGND VGND VPWR VPWR _3323_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_15_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3726_ _1397_ _1420_ _1401_ VGND VGND VPWR VPWR _1421_ sky130_fd_sc_hd__o21a_1
X_7494_ clknet_leaf_29_clk _1053_ VGND VGND VPWR VPWR memory\[24\]\[23\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_70_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_576 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_101_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6445_ net1096 _3275_ _3280_ _3284_ VGND VGND VPWR VPWR _0230_ sky130_fd_sc_hd__a31o_1
XFILLER_0_3_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3657_ memory\[24\]\[8\] memory\[25\]\[8\] memory\[26\]\[8\] memory\[27\]\[8\] _1353_
+ _1354_ VGND VGND VPWR VPWR _1355_ sky130_fd_sc_hd__mux4_1
X_6376_ _2847_ _3238_ VGND VGND VPWR VPWR _3244_ sky130_fd_sc_hd__and2_1
X_3588_ _1245_ _1289_ VGND VGND VPWR VPWR _1290_ sky130_fd_sc_hd__or2_1
X_5327_ _2455_ _2739_ _2741_ net222 VGND VGND VPWR VPWR _0680_ sky130_fd_sc_hd__a22o_1
X_5258_ net987 _2675_ _2693_ _2701_ VGND VGND VPWR VPWR _0651_ sky130_fd_sc_hd__a31o_1
X_5189_ net37 VGND VGND VPWR VPWR _2673_ sky130_fd_sc_hd__buf_4
X_4209_ _1862_ _1870_ _1875_ _1881_ _1851_ VGND VGND VPWR VPWR _1882_ sky130_fd_sc_hd__a221o_1
XFILLER_0_3_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_104_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_84_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_1182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4560_ _2215_ VGND VGND VPWR VPWR _0041_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_107_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_8_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_4_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold617 memory\[8\]\[20\] VGND VGND VPWR VPWR net826 sky130_fd_sc_hd__dlygate4sd3_1
Xhold606 memory\[23\]\[24\] VGND VGND VPWR VPWR net815 sky130_fd_sc_hd__dlygate4sd3_1
X_4491_ memory\[24\]\[15\] memory\[25\]\[15\] memory\[26\]\[15\] memory\[27\]\[15\]
+ _2032_ _2033_ VGND VGND VPWR VPWR _2150_ sky130_fd_sc_hd__mux4_1
X_3511_ memory\[28\]\[1\] memory\[29\]\[1\] memory\[30\]\[1\] memory\[31\]\[1\] _1178_
+ _1179_ VGND VGND VPWR VPWR _1216_ sky130_fd_sc_hd__mux4_1
Xhold628 memory\[26\]\[20\] VGND VGND VPWR VPWR net837 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_110_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold639 memory\[8\]\[30\] VGND VGND VPWR VPWR net848 sky130_fd_sc_hd__dlygate4sd3_1
X_6230_ _2893_ _3167_ VGND VGND VPWR VPWR _3174_ sky130_fd_sc_hd__and2_1
XFILLER_0_40_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6161_ net393 _3130_ _3122_ _3133_ VGND VGND VPWR VPWR _1122_ sky130_fd_sc_hd__a31o_1
XFILLER_0_0_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_900 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_110_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5112_ _2619_ _2609_ VGND VGND VPWR VPWR _2620_ sky130_fd_sc_hd__and2_1
XTAP_911 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_922 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_933 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_944 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6092_ _2444_ _2445_ _2443_ VGND VGND VPWR VPWR _3093_ sky130_fd_sc_hd__and3b_4
XTAP_977 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_966 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_955 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_999 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_988 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5043_ net1154 _2572_ _2573_ VGND VGND VPWR VPWR _2576_ sky130_fd_sc_hd__and3_1
XFILLER_0_18_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_79_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6994_ clknet_leaf_4_clk _0585_ VGND VGND VPWR VPWR memory\[26\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_87_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5945_ _3009_ VGND VGND VPWR VPWR _3010_ sky130_fd_sc_hd__buf_2
X_5876_ _2842_ _2965_ VGND VGND VPWR VPWR _2970_ sky130_fd_sc_hd__and2_1
XFILLER_0_47_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7615_ clknet_leaf_95_clk _0149_ VGND VGND VPWR VPWR memory\[27\]\[16\] sky130_fd_sc_hd__dfxtp_1
X_4827_ _2460_ _2449_ _2453_ net435 VGND VGND VPWR VPWR _0460_ sky130_fd_sc_hd__a22o_1
XFILLER_0_118_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4758_ _1850_ _2398_ _2400_ _2402_ _2249_ VGND VGND VPWR VPWR _2403_ sky130_fd_sc_hd__a221o_1
XFILLER_0_71_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7546_ clknet_leaf_94_clk _1105_ VGND VGND VPWR VPWR memory\[20\]\[11\] sky130_fd_sc_hd__dfxtp_1
X_4689_ memory\[24\]\[26\] memory\[25\]\[26\] memory\[26\]\[26\] memory\[27\]\[26\]
+ _1872_ _1873_ VGND VGND VPWR VPWR _2337_ sky130_fd_sc_hd__mux4_1
X_3709_ memory\[4\]\[10\] memory\[5\]\[10\] memory\[6\]\[10\] memory\[7\]\[10\] _1360_
+ _1361_ VGND VGND VPWR VPWR _1405_ sky130_fd_sc_hd__mux4_1
X_7477_ clknet_leaf_2_clk _1036_ VGND VGND VPWR VPWR memory\[24\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_6428_ _2899_ _3264_ VGND VGND VPWR VPWR _3273_ sky130_fd_sc_hd__and2_1
XFILLER_0_31_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6359_ _2678_ _3225_ _3227_ net256 VGND VGND VPWR VPWR _0196_ sky130_fd_sc_hd__a22o_1
XFILLER_0_11_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_14_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_121_19 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_81_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold3 memory\[17\]\[3\] VGND VGND VPWR VPWR net212 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_89_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3991_ memory\[0\]\[24\] memory\[1\]\[24\] memory\[2\]\[24\] memory\[3\]\[24\] _1271_
+ _1272_ VGND VGND VPWR VPWR _1673_ sky130_fd_sc_hd__mux4_1
X_5730_ net1018 _2890_ _2880_ _2896_ VGND VGND VPWR VPWR _0896_ sky130_fd_sc_hd__a31o_1
XFILLER_0_71_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5548__24 clknet_1_0__leaf__2785_ VGND VGND VPWR VPWR net169 sky130_fd_sc_hd__inv_2
X_7400_ clknet_leaf_30_clk _0959_ VGND VGND VPWR VPWR memory\[25\]\[25\] sky130_fd_sc_hd__dfxtp_1
X_5661_ net530 _2844_ _2833_ _2848_ VGND VGND VPWR VPWR _0875_ sky130_fd_sc_hd__a31o_1
X_4612_ memory\[12\]\[21\] memory\[13\]\[21\] memory\[14\]\[21\] memory\[15\]\[21\]
+ _2045_ _2046_ VGND VGND VPWR VPWR _2265_ sky130_fd_sc_hd__mux4_1
X_5592_ _2634_ _2804_ VGND VGND VPWR VPWR _2806_ sky130_fd_sc_hd__and2_1
Xclkbuf_4_4_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_4_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_115_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7331_ clknet_leaf_65_clk _0890_ VGND VGND VPWR VPWR memory\[7\]\[20\] sky130_fd_sc_hd__dfxtp_1
X_4543_ memory\[20\]\[18\] memory\[21\]\[18\] memory\[22\]\[18\] memory\[23\]\[18\]
+ _1938_ _1939_ VGND VGND VPWR VPWR _2199_ sky130_fd_sc_hd__mux4_1
XFILLER_0_111_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7262_ net165 _0006_ VGND VGND VPWR VPWR net88 sky130_fd_sc_hd__dfxtp_2
Xhold403 memory\[21\]\[11\] VGND VGND VPWR VPWR net612 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_4_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold414 memory\[7\]\[11\] VGND VGND VPWR VPWR net623 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold425 memory\[28\]\[4\] VGND VGND VPWR VPWR net634 sky130_fd_sc_hd__dlygate4sd3_1
Xhold436 memory\[28\]\[17\] VGND VGND VPWR VPWR net645 sky130_fd_sc_hd__dlygate4sd3_1
Xhold447 memory\[24\]\[25\] VGND VGND VPWR VPWR net656 sky130_fd_sc_hd__dlygate4sd3_1
Xhold469 memory\[14\]\[4\] VGND VGND VPWR VPWR net678 sky130_fd_sc_hd__dlygate4sd3_1
X_4474_ memory\[20\]\[14\] memory\[21\]\[14\] memory\[22\]\[14\] memory\[23\]\[14\]
+ _1831_ _1833_ VGND VGND VPWR VPWR _2134_ sky130_fd_sc_hd__mux4_1
Xhold458 memory\[20\]\[12\] VGND VGND VPWR VPWR net667 sky130_fd_sc_hd__dlygate4sd3_1
X_6213_ _2876_ _3154_ VGND VGND VPWR VPWR _3164_ sky130_fd_sc_hd__and2_1
X_7193_ clknet_leaf_47_clk _0784_ VGND VGND VPWR VPWR memory\[14\]\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_110_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6144_ net577 _3117_ _3122_ _3124_ VGND VGND VPWR VPWR _1114_ sky130_fd_sc_hd__a31o_1
XTAP_730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6075_ _2891_ _3079_ VGND VGND VPWR VPWR _3084_ sky130_fd_sc_hd__and2_1
XTAP_763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_785 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_774 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5026_ net1152 _2557_ _2560_ VGND VGND VPWR VPWR _2566_ sky130_fd_sc_hd__and3_1
XFILLER_0_31_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_796 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_leaf_92_clk clknet_4_4_0_clk VGND VGND VPWR VPWR clknet_leaf_92_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_67_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6977_ clknet_leaf_85_clk _0568_ VGND VGND VPWR VPWR memory\[6\]\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_48_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5928_ _2895_ _2991_ VGND VGND VPWR VPWR _2999_ sky130_fd_sc_hd__and2_1
XFILLER_0_48_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5859_ net1108 _2600_ _2920_ VGND VGND VPWR VPWR _2958_ sky130_fd_sc_hd__and3_1
XFILLER_0_8_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7529_ clknet_leaf_50_clk _1088_ VGND VGND VPWR VPWR memory\[11\]\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_31_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_101_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_98_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_83_clk clknet_4_7_0_clk VGND VGND VPWR VPWR clknet_leaf_83_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_86_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_66_295 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_54_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_112_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_120_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4190_ _1799_ VGND VGND VPWR VPWR _1863_ sky130_fd_sc_hd__buf_8
XFILLER_0_5_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7880_ clknet_leaf_58_clk _0414_ VGND VGND VPWR VPWR memory\[13\]\[25\] sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_74_clk clknet_4_12_0_clk VGND VGND VPWR VPWR clknet_leaf_74_clk sky130_fd_sc_hd__clkbuf_16
X_6900_ clknet_leaf_20_clk _0491_ VGND VGND VPWR VPWR memory\[15\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_106_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3974_ _1486_ _1656_ _1488_ VGND VGND VPWR VPWR _1657_ sky130_fd_sc_hd__o21a_1
XFILLER_0_85_571 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6762_ _3430_ VGND VGND VPWR VPWR _3433_ sky130_fd_sc_hd__clkbuf_4
X_5713_ _2884_ _2882_ VGND VGND VPWR VPWR _2885_ sky130_fd_sc_hd__and2_1
X_6693_ net46 _3388_ VGND VGND VPWR VPWR _3398_ sky130_fd_sc_hd__and2_1
X_5644_ _2834_ _2836_ VGND VGND VPWR VPWR _2837_ sky130_fd_sc_hd__and2_1
XFILLER_0_60_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold211 memory\[13\]\[26\] VGND VGND VPWR VPWR net420 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_103_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold200 memory\[5\]\[21\] VGND VGND VPWR VPWR net409 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_79_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5575_ _2617_ _2791_ VGND VGND VPWR VPWR _2796_ sky130_fd_sc_hd__and2_1
X_7314_ clknet_leaf_104_clk _0873_ VGND VGND VPWR VPWR memory\[7\]\[3\] sky130_fd_sc_hd__dfxtp_1
Xhold244 memory\[13\]\[27\] VGND VGND VPWR VPWR net453 sky130_fd_sc_hd__dlygate4sd3_1
Xhold222 memory\[29\]\[28\] VGND VGND VPWR VPWR net431 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold233 memory\[3\]\[9\] VGND VGND VPWR VPWR net442 sky130_fd_sc_hd__dlygate4sd3_1
X_4526_ memory\[28\]\[17\] memory\[29\]\[17\] memory\[30\]\[17\] memory\[31\]\[17\]
+ _1960_ _1961_ VGND VGND VPWR VPWR _2183_ sky130_fd_sc_hd__mux4_1
X_7245_ clknet_leaf_23_clk _0836_ VGND VGND VPWR VPWR memory\[31\]\[30\] sky130_fd_sc_hd__dfxtp_1
X_4457_ _1796_ VGND VGND VPWR VPWR _2118_ sky130_fd_sc_hd__buf_4
Xhold266 memory\[9\]\[15\] VGND VGND VPWR VPWR net475 sky130_fd_sc_hd__dlygate4sd3_1
Xhold255 memory\[22\]\[0\] VGND VGND VPWR VPWR net464 sky130_fd_sc_hd__dlygate4sd3_1
Xhold277 memory\[31\]\[2\] VGND VGND VPWR VPWR net486 sky130_fd_sc_hd__dlygate4sd3_1
X_7176_ clknet_leaf_64_clk _0767_ VGND VGND VPWR VPWR memory\[2\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_0_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold288 memory\[24\]\[14\] VGND VGND VPWR VPWR net497 sky130_fd_sc_hd__dlygate4sd3_1
Xhold299 memory\[29\]\[14\] VGND VGND VPWR VPWR net508 sky130_fd_sc_hd__dlygate4sd3_1
X_4388_ memory\[16\]\[10\] memory\[17\]\[10\] memory\[18\]\[10\] memory\[19\]\[10\]
+ _2028_ _2029_ VGND VGND VPWR VPWR _2052_ sky130_fd_sc_hd__mux4_1
X_6127_ net499 _3104_ _3109_ _3114_ VGND VGND VPWR VPWR _1107_ sky130_fd_sc_hd__a31o_1
XTAP_560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6058_ _2874_ _3066_ VGND VGND VPWR VPWR _3074_ sky130_fd_sc_hd__and2_1
Xclkbuf_leaf_65_clk clknet_4_13_0_clk VGND VGND VPWR VPWR clknet_leaf_65_clk sky130_fd_sc_hd__clkbuf_16
X_5009_ _2443_ _2444_ _2445_ VGND VGND VPWR VPWR _2554_ sky130_fd_sc_hd__or3b_2
XANTENNA_106 _1978_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_1715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_128 _2888_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_139 net39 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_117 _2861_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_1748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_119_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f__2785_ clknet_0__2785_ VGND VGND VPWR VPWR clknet_1_1__leaf__2785_
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_56_clk clknet_4_15_0_clk VGND VGND VPWR VPWR clknet_leaf_56_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_86_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_59_538 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_55_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3690_ _1385_ _1386_ _1205_ VGND VGND VPWR VPWR _1387_ sky130_fd_sc_hd__mux2_1
XFILLER_0_42_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5360_ _2488_ _2738_ _2740_ net313 VGND VGND VPWR VPWR _0709_ sky130_fd_sc_hd__a22o_1
X_5291_ _2692_ VGND VGND VPWR VPWR _2720_ sky130_fd_sc_hd__buf_4
XFILLER_0_23_696 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4311_ _1963_ _1969_ _1977_ _1978_ _1827_ VGND VGND VPWR VPWR _1979_ sky130_fd_sc_hd__a221o_1
XFILLER_0_120_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4242_ _1830_ VGND VGND VPWR VPWR _1913_ sky130_fd_sc_hd__clkbuf_8
X_7030_ clknet_leaf_112_clk _0621_ VGND VGND VPWR VPWR memory\[16\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_4173_ memory\[0\]\[0\] memory\[1\]\[0\] memory\[2\]\[0\] memory\[3\]\[0\] _1845_
+ _1846_ VGND VGND VPWR VPWR _1847_ sky130_fd_sc_hd__mux4_1
X_7932_ net195 _0036_ VGND VGND VPWR VPWR net54 sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_47_clk clknet_4_12_0_clk VGND VGND VPWR VPWR clknet_leaf_47_clk sky130_fd_sc_hd__clkbuf_16
X_7863_ clknet_leaf_22_clk _0397_ VGND VGND VPWR VPWR memory\[13\]\[8\] sky130_fd_sc_hd__dfxtp_1
X_6814_ _3437_ VGND VGND VPWR VPWR _3443_ sky130_fd_sc_hd__buf_4
X_7794_ clknet_leaf_21_clk _0328_ VGND VGND VPWR VPWR memory\[12\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_3957_ _1479_ _1636_ _1638_ _1640_ _1606_ VGND VGND VPWR VPWR _1641_ sky130_fd_sc_hd__a221o_1
XFILLER_0_92_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6745_ net270 _2509_ _3385_ _3426_ VGND VGND VPWR VPWR _0388_ sky130_fd_sc_hd__a31o_1
XFILLER_0_46_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_116_665 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_116_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_202 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3888_ memory\[4\]\[19\] memory\[5\]\[19\] memory\[6\]\[19\] memory\[7\]\[19\] _1360_
+ _1361_ VGND VGND VPWR VPWR _1575_ sky130_fd_sc_hd__mux4_1
X_6676_ net16 _3388_ VGND VGND VPWR VPWR _3389_ sky130_fd_sc_hd__and2_1
X_5627_ net611 _2824_ _2816_ _2825_ VGND VGND VPWR VPWR _0864_ sky130_fd_sc_hd__a31o_1
XFILLER_0_103_304 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_60_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_103_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_13_140 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4509_ memory\[24\]\[16\] memory\[25\]\[16\] memory\[26\]\[16\] memory\[27\]\[16\]
+ _2032_ _2033_ VGND VGND VPWR VPWR _2167_ sky130_fd_sc_hd__mux4_1
X_7228_ clknet_leaf_87_clk _0819_ VGND VGND VPWR VPWR memory\[31\]\[13\] sky130_fd_sc_hd__dfxtp_1
X_5489_ _2777_ VGND VGND VPWR VPWR _2778_ sky130_fd_sc_hd__clkbuf_4
X_7159_ clknet_leaf_101_clk _0750_ VGND VGND VPWR VPWR memory\[2\]\[8\] sky130_fd_sc_hd__dfxtp_1
XTAP_390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_38_clk clknet_4_11_0_clk VGND VGND VPWR VPWR clknet_leaf_38_clk sky130_fd_sc_hd__clkbuf_16
XTAP_1523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_519 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_119_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_122_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_121_156 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_121_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_102_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_29_clk clknet_4_10_0_clk VGND VGND VPWR VPWR clknet_leaf_29_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_59_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4860_ net30 VGND VGND VPWR VPWR _2479_ sky130_fd_sc_hd__buf_4
XFILLER_0_74_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3811_ memory\[12\]\[15\] memory\[13\]\[15\] memory\[14\]\[15\] memory\[15\]\[15\]
+ _1188_ _1190_ VGND VGND VPWR VPWR _1502_ sky130_fd_sc_hd__mux4_1
XFILLER_0_28_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_28 _2484_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4791_ memory\[4\]\[31\] memory\[5\]\[31\] memory\[6\]\[31\] memory\[7\]\[31\] _1960_
+ _1961_ VGND VGND VPWR VPWR _2434_ sky130_fd_sc_hd__mux4_1
XANTENNA_17 _1842_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_39 _2684_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6530_ _2508_ VGND VGND VPWR VPWR _3333_ sky130_fd_sc_hd__clkbuf_4
X_3742_ memory\[20\]\[12\] memory\[21\]\[12\] memory\[22\]\[12\] memory\[23\]\[12\]
+ _1312_ _1313_ VGND VGND VPWR VPWR _1436_ sky130_fd_sc_hd__mux4_1
XFILLER_0_42_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_103_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6461_ _2855_ _3282_ VGND VGND VPWR VPWR _3293_ sky130_fd_sc_hd__and2_1
X_3673_ _1236_ _1366_ _1368_ _1370_ _1208_ VGND VGND VPWR VPWR _1371_ sky130_fd_sc_hd__a221o_1
XFILLER_0_113_646 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6392_ net612 _3249_ _3250_ _3253_ VGND VGND VPWR VPWR _0208_ sky130_fd_sc_hd__a31o_1
XFILLER_0_30_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5412_ _2457_ _2758_ _2760_ net309 VGND VGND VPWR VPWR _0746_ sky130_fd_sc_hd__a22o_1
XFILLER_0_2_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5343_ _2471_ _2742_ _2743_ net661 VGND VGND VPWR VPWR _0694_ sky130_fd_sc_hd__a22o_1
Xoutput113 net113 VGND VGND VPWR VPWR data_out2[9] sky130_fd_sc_hd__clkbuf_4
Xoutput102 net102 VGND VGND VPWR VPWR data_out2[28] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_2_398 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5274_ _2636_ _2708_ VGND VGND VPWR VPWR _2711_ sky130_fd_sc_hd__and2_1
X_7013_ clknet_leaf_31_clk _0604_ VGND VGND VPWR VPWR memory\[26\]\[22\] sky130_fd_sc_hd__dfxtp_1
X_4225_ memory\[12\]\[2\] memory\[13\]\[2\] memory\[14\]\[2\] memory\[15\]\[2\] _1877_
+ _1878_ VGND VGND VPWR VPWR _1897_ sky130_fd_sc_hd__mux4_2
X_4156_ net1 VGND VGND VPWR VPWR _1830_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_97_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4087_ memory\[16\]\[30\] memory\[17\]\[30\] memory\[18\]\[30\] memory\[19\]\[30\]
+ _1157_ _1159_ VGND VGND VPWR VPWR _1763_ sky130_fd_sc_hd__mux4_1
XFILLER_0_78_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7915_ clknet_leaf_26_clk _0449_ VGND VGND VPWR VPWR memory\[17\]\[28\] sky130_fd_sc_hd__dfxtp_1
X_7846_ clknet_leaf_57_clk _0380_ VGND VGND VPWR VPWR memory\[9\]\[23\] sky130_fd_sc_hd__dfxtp_1
X_4989_ net1169 _2543_ _2540_ VGND VGND VPWR VPWR _2544_ sky130_fd_sc_hd__and3_1
XFILLER_0_65_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_7777_ clknet_leaf_78_clk _0311_ VGND VGND VPWR VPWR memory\[30\]\[18\] sky130_fd_sc_hd__dfxtp_1
X_6728_ net31 _3414_ VGND VGND VPWR VPWR _3418_ sky130_fd_sc_hd__and2_1
XFILLER_0_61_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_0__2787_ _2787_ VGND VGND VPWR VPWR clknet_0__2787_ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_18_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6659_ _2654_ _3382_ _3383_ net260 VGND VGND VPWR VPWR _0345_ sky130_fd_sc_hd__a22o_1
XFILLER_0_61_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_104_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_103_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6848__55 clknet_1_1__leaf__3446_ VGND VGND VPWR VPWR net200 sky130_fd_sc_hd__inv_2
XTAP_1331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_1375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput37 data_in[29] VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__buf_2
Xinput26 data_in[19] VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__buf_2
Xinput15 data_addr[4] VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__buf_2
XFILLER_0_92_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput48 reset VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_109_7 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_12_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4010_ _1486_ _1690_ _1488_ VGND VGND VPWR VPWR _1691_ sky130_fd_sc_hd__o21a_1
X_5961_ net874 _3006_ _3008_ _3018_ VGND VGND VPWR VPWR _1037_ sky130_fd_sc_hd__a31o_1
X_4912_ _2475_ _2499_ _2500_ net752 VGND VGND VPWR VPWR _0505_ sky130_fd_sc_hd__a22o_1
XFILLER_0_75_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_75_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7700_ clknet_leaf_110_clk _0234_ VGND VGND VPWR VPWR memory\[5\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_114_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_7631_ clknet_leaf_0_clk _0165_ VGND VGND VPWR VPWR memory\[19\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_5892_ _2858_ _2978_ VGND VGND VPWR VPWR _2979_ sky130_fd_sc_hd__and2_1
XFILLER_0_114_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_114_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4843_ _2469_ _2464_ _2465_ net540 VGND VGND VPWR VPWR _0467_ sky130_fd_sc_hd__a22o_1
XFILLER_0_99_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4774_ memory\[12\]\[30\] memory\[13\]\[30\] memory\[14\]\[30\] memory\[15\]\[30\]
+ _1965_ _1966_ VGND VGND VPWR VPWR _2418_ sky130_fd_sc_hd__mux4_1
X_7562_ clknet_leaf_24_clk _1121_ VGND VGND VPWR VPWR memory\[20\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_7_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7493_ clknet_leaf_28_clk _1052_ VGND VGND VPWR VPWR memory\[24\]\[22\] sky130_fd_sc_hd__dfxtp_1
X_6513_ _2502_ _3093_ VGND VGND VPWR VPWR _3322_ sky130_fd_sc_hd__or2b_1
X_3725_ memory\[28\]\[11\] memory\[29\]\[11\] memory\[30\]\[11\] memory\[31\]\[11\]
+ _1398_ _1399_ VGND VGND VPWR VPWR _1420_ sky130_fd_sc_hd__mux4_1
X_6444_ _2838_ _3282_ VGND VGND VPWR VPWR _3284_ sky130_fd_sc_hd__and2_1
Xclkbuf_leaf_9_clk clknet_4_2_0_clk VGND VGND VPWR VPWR clknet_leaf_9_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_70_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3656_ _1189_ VGND VGND VPWR VPWR _1354_ sky130_fd_sc_hd__buf_4
XFILLER_0_43_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6375_ net713 _3233_ _3236_ _3243_ VGND VGND VPWR VPWR _0201_ sky130_fd_sc_hd__a31o_1
X_3587_ memory\[8\]\[4\] memory\[9\]\[4\] memory\[10\]\[4\] memory\[11\]\[4\] _1246_
+ _1247_ VGND VGND VPWR VPWR _1289_ sky130_fd_sc_hd__mux4_1
XFILLER_0_11_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5326_ _2454_ _2739_ _2741_ net219 VGND VGND VPWR VPWR _0679_ sky130_fd_sc_hd__a22o_1
X_5257_ _2619_ _2695_ VGND VGND VPWR VPWR _2701_ sky130_fd_sc_hd__and2_1
X_4208_ _1876_ _1879_ _1880_ VGND VGND VPWR VPWR _1881_ sky130_fd_sc_hd__o21a_1
X_5188_ net360 _2652_ _2653_ _2672_ VGND VGND VPWR VPWR _0610_ sky130_fd_sc_hd__a31o_1
X_4139_ net1 VGND VGND VPWR VPWR _1813_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_65_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7829_ clknet_leaf_13_clk _0363_ VGND VGND VPWR VPWR memory\[9\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_81_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_61_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_104_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_57_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_80_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3510_ _1169_ _1214_ VGND VGND VPWR VPWR _1215_ sky130_fd_sc_hd__or2_1
Xhold618 memory\[20\]\[30\] VGND VGND VPWR VPWR net827 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4490_ _2147_ _2148_ _1903_ VGND VGND VPWR VPWR _2149_ sky130_fd_sc_hd__mux2_1
Xhold607 memory\[19\]\[1\] VGND VGND VPWR VPWR net816 sky130_fd_sc_hd__dlygate4sd3_1
Xhold629 memory\[17\]\[11\] VGND VGND VPWR VPWR net838 sky130_fd_sc_hd__dlygate4sd3_1
X_6160_ _2899_ _3123_ VGND VGND VPWR VPWR _3133_ sky130_fd_sc_hd__and2_1
XFILLER_0_20_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_901 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5111_ net43 VGND VGND VPWR VPWR _2619_ sky130_fd_sc_hd__buf_4
XTAP_912 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_923 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_934 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6091_ net479 _3088_ _3050_ _3092_ VGND VGND VPWR VPWR _1093_ sky130_fd_sc_hd__a31o_1
XTAP_978 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_967 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_956 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_945 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_989 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5042_ _2466_ _2571_ _2575_ VGND VGND VPWR VPWR _0561_ sky130_fd_sc_hd__a21o_1
XFILLER_0_109_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_205 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6993_ clknet_leaf_0_clk _0584_ VGND VGND VPWR VPWR memory\[26\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_5944_ _2440_ _2441_ _2690_ _2603_ VGND VGND VPWR VPWR _3009_ sky130_fd_sc_hd__and4_4
XFILLER_0_75_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5875_ net935 _2968_ _2963_ _2969_ VGND VGND VPWR VPWR _1000_ sky130_fd_sc_hd__a31o_1
X_4826_ net45 VGND VGND VPWR VPWR _2460_ sky130_fd_sc_hd__buf_4
X_7614_ clknet_leaf_95_clk _0148_ VGND VGND VPWR VPWR memory\[27\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_28_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7545_ clknet_leaf_94_clk _1104_ VGND VGND VPWR VPWR memory\[20\]\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_16_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4757_ _1964_ _2401_ _1968_ VGND VGND VPWR VPWR _2402_ sky130_fd_sc_hd__o21a_1
XFILLER_0_16_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4688_ _2336_ VGND VGND VPWR VPWR _0049_ sky130_fd_sc_hd__buf_1
XFILLER_0_71_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7476_ clknet_leaf_0_clk _1035_ VGND VGND VPWR VPWR memory\[24\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_3708_ _1390_ _1393_ _1396_ _1402_ _1403_ VGND VGND VPWR VPWR _1404_ sky130_fd_sc_hd__a221o_1
XFILLER_0_101_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6427_ net775 _3262_ _3263_ _3272_ VGND VGND VPWR VPWR _0224_ sky130_fd_sc_hd__a31o_1
XFILLER_0_31_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3639_ _1155_ _1333_ _1335_ _1337_ _1184_ VGND VGND VPWR VPWR _1338_ sky130_fd_sc_hd__a221o_1
X_6358_ _2676_ _3225_ _3227_ net528 VGND VGND VPWR VPWR _0195_ sky130_fd_sc_hd__a22o_1
XFILLER_0_3_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5309_ _2529_ VGND VGND VPWR VPWR _2730_ sky130_fd_sc_hd__buf_4
X_6289_ net377 _3200_ _3196_ _3207_ VGND VGND VPWR VPWR _0151_ sky130_fd_sc_hd__a31o_1
XFILLER_0_98_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_19_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold4 memory\[12\]\[23\] VGND VGND VPWR VPWR net213 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_55_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3990_ memory\[4\]\[24\] memory\[5\]\[24\] memory\[6\]\[24\] memory\[7\]\[24\] _1199_
+ _1200_ VGND VGND VPWR VPWR _1672_ sky130_fd_sc_hd__mux4_1
XFILLER_0_57_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5660_ _2847_ _2836_ VGND VGND VPWR VPWR _2848_ sky130_fd_sc_hd__and2_1
XFILLER_0_45_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_115_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4611_ _2101_ _2263_ VGND VGND VPWR VPWR _2264_ sky130_fd_sc_hd__or2_1
XFILLER_0_45_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5591_ net425 _2798_ _2803_ _2805_ VGND VGND VPWR VPWR _0848_ sky130_fd_sc_hd__a31o_1
XFILLER_0_25_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7330_ clknet_leaf_83_clk _0889_ VGND VGND VPWR VPWR memory\[7\]\[19\] sky130_fd_sc_hd__dfxtp_1
X_4542_ _2198_ VGND VGND VPWR VPWR _0040_ sky130_fd_sc_hd__clkbuf_1
X_7261_ net164 _0005_ VGND VGND VPWR VPWR net87 sky130_fd_sc_hd__dfxtp_1
Xhold404 memory\[22\]\[2\] VGND VGND VPWR VPWR net613 sky130_fd_sc_hd__dlygate4sd3_1
Xhold426 memory\[1\]\[6\] VGND VGND VPWR VPWR net635 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold415 memory\[28\]\[9\] VGND VGND VPWR VPWR net624 sky130_fd_sc_hd__dlygate4sd3_1
X_4473_ _1964_ _2132_ _1968_ VGND VGND VPWR VPWR _2133_ sky130_fd_sc_hd__o21a_1
Xhold448 memory\[28\]\[20\] VGND VGND VPWR VPWR net657 sky130_fd_sc_hd__dlygate4sd3_1
X_6212_ net972 _3159_ _3153_ _3163_ VGND VGND VPWR VPWR _1143_ sky130_fd_sc_hd__a31o_1
Xhold459 memory\[18\]\[17\] VGND VGND VPWR VPWR net668 sky130_fd_sc_hd__dlygate4sd3_1
Xhold437 memory\[4\]\[15\] VGND VGND VPWR VPWR net646 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_96_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7192_ clknet_leaf_22_clk _0783_ VGND VGND VPWR VPWR memory\[14\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_21_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6143_ _2881_ _3123_ VGND VGND VPWR VPWR _3124_ sky130_fd_sc_hd__and2_1
XFILLER_0_0_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6074_ net565 _3075_ _3078_ _3083_ VGND VGND VPWR VPWR _1085_ sky130_fd_sc_hd__a31o_1
XTAP_753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_786 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_775 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5025_ _2457_ _2556_ _2565_ VGND VGND VPWR VPWR _0554_ sky130_fd_sc_hd__a21o_1
XTAP_797 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6976_ clknet_leaf_83_clk _0567_ VGND VGND VPWR VPWR memory\[6\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_48_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5927_ net786 _2994_ _2990_ _2998_ VGND VGND VPWR VPWR _1023_ sky130_fd_sc_hd__a31o_1
XFILLER_0_0_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_0_72 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5858_ _2486_ _2946_ _2957_ VGND VGND VPWR VPWR _0963_ sky130_fd_sc_hd__a21o_1
XFILLER_0_106_549 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4809_ set\[0\] _0517_ VGND VGND VPWR VPWR _2450_ sky130_fd_sc_hd__nand2_4
X_5789_ _2917_ VGND VGND VPWR VPWR _2918_ sky130_fd_sc_hd__buf_4
XFILLER_0_63_469 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_7528_ clknet_leaf_48_clk _1087_ VGND VGND VPWR VPWR memory\[11\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_16_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7459_ clknet_leaf_66_clk _1018_ VGND VGND VPWR VPWR memory\[1\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_9_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold960 memory\[10\]\[22\] VGND VGND VPWR VPWR net1169 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_98_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_26_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_89_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_119_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6761_ _3428_ VGND VGND VPWR VPWR _3432_ sky130_fd_sc_hd__clkbuf_4
X_3973_ memory\[12\]\[23\] memory\[13\]\[23\] memory\[14\]\[23\] memory\[15\]\[23\]
+ _1430_ _1431_ VGND VGND VPWR VPWR _1656_ sky130_fd_sc_hd__mux4_1
X_5712_ net29 VGND VGND VPWR VPWR _2884_ sky130_fd_sc_hd__buf_4
XFILLER_0_122_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_85_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6692_ net1088 _3393_ _3386_ _3397_ VGND VGND VPWR VPWR _0364_ sky130_fd_sc_hd__a31o_1
XFILLER_0_57_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5643_ _2835_ VGND VGND VPWR VPWR _2836_ sky130_fd_sc_hd__buf_2
XFILLER_0_122_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5574_ net913 _2731_ _2789_ _2795_ VGND VGND VPWR VPWR _0841_ sky130_fd_sc_hd__a31o_1
XFILLER_0_25_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_115_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold201 memory\[14\]\[5\] VGND VGND VPWR VPWR net410 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7313_ clknet_leaf_104_clk _0872_ VGND VGND VPWR VPWR memory\[7\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_4525_ _1959_ _2181_ VGND VGND VPWR VPWR _2182_ sky130_fd_sc_hd__or2_1
XFILLER_0_41_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold223 memory\[1\]\[27\] VGND VGND VPWR VPWR net432 sky130_fd_sc_hd__dlygate4sd3_1
Xhold212 memory\[27\]\[5\] VGND VGND VPWR VPWR net421 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold234 memory\[9\]\[2\] VGND VGND VPWR VPWR net443 sky130_fd_sc_hd__dlygate4sd3_1
X_7244_ clknet_leaf_35_clk _0835_ VGND VGND VPWR VPWR memory\[31\]\[29\] sky130_fd_sc_hd__dfxtp_1
Xhold245 memory\[11\]\[18\] VGND VGND VPWR VPWR net454 sky130_fd_sc_hd__dlygate4sd3_1
Xhold256 memory\[9\]\[13\] VGND VGND VPWR VPWR net465 sky130_fd_sc_hd__dlygate4sd3_1
X_4456_ memory\[28\]\[13\] memory\[29\]\[13\] memory\[30\]\[13\] memory\[31\]\[13\]
+ _2092_ _2093_ VGND VGND VPWR VPWR _2117_ sky130_fd_sc_hd__mux4_1
Xhold278 memory\[17\]\[19\] VGND VGND VPWR VPWR net487 sky130_fd_sc_hd__dlygate4sd3_1
Xhold267 memory\[18\]\[19\] VGND VGND VPWR VPWR net476 sky130_fd_sc_hd__dlygate4sd3_1
Xhold289 memory\[29\]\[22\] VGND VGND VPWR VPWR net498 sky130_fd_sc_hd__dlygate4sd3_1
X_7175_ clknet_leaf_57_clk _0766_ VGND VGND VPWR VPWR memory\[2\]\[24\] sky130_fd_sc_hd__dfxtp_1
X_4387_ memory\[20\]\[10\] memory\[21\]\[10\] memory\[22\]\[10\] memory\[23\]\[10\]
+ _1938_ _1939_ VGND VGND VPWR VPWR _2051_ sky130_fd_sc_hd__mux4_1
XFILLER_0_0_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6126_ _2865_ _3110_ VGND VGND VPWR VPWR _3114_ sky130_fd_sc_hd__and2_1
XTAP_550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6057_ net1078 _3062_ _3065_ _3073_ VGND VGND VPWR VPWR _1078_ sky130_fd_sc_hd__a31o_1
X_5008_ _2488_ _2504_ _2553_ VGND VGND VPWR VPWR _0549_ sky130_fd_sc_hd__a21o_1
XANTENNA_107 _1978_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_1705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_129 _2888_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_118 _2861_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_1749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6959_ clknet_leaf_108_clk _0550_ VGND VGND VPWR VPWR memory\[6\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_48_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_106_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold790 memory\[17\]\[27\] VGND VGND VPWR VPWR net999 sky130_fd_sc_hd__dlygate4sd3_1
Xclkbuf_4_3_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_3_0_clk sky130_fd_sc_hd__clkbuf_8
Xclkbuf_1_1__f__2784_ clknet_0__2784_ VGND VGND VPWR VPWR clknet_1_1__leaf__2784_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_99_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_52_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_109_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4310_ _1797_ VGND VGND VPWR VPWR _1978_ sky130_fd_sc_hd__clkbuf_8
X_5290_ net831 _2717_ _2707_ _2719_ VGND VGND VPWR VPWR _0665_ sky130_fd_sc_hd__a31o_1
XFILLER_0_22_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_494 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_77_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4241_ _1910_ _1911_ _1869_ VGND VGND VPWR VPWR _1912_ sky130_fd_sc_hd__mux2_1
X_4172_ _1801_ VGND VGND VPWR VPWR _1846_ sky130_fd_sc_hd__clkbuf_8
X_7931_ net194 _0035_ VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_26_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7862_ clknet_leaf_20_clk _0396_ VGND VGND VPWR VPWR memory\[13\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_77_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7793_ clknet_leaf_6_clk _0327_ VGND VGND VPWR VPWR memory\[12\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_6813_ _2650_ _3441_ _3442_ net487 VGND VGND VPWR VPWR _0440_ sky130_fd_sc_hd__a22o_1
X_3956_ _1486_ _1639_ _1488_ VGND VGND VPWR VPWR _1640_ sky130_fd_sc_hd__o21a_1
X_6744_ net40 _3387_ VGND VGND VPWR VPWR _3426_ sky130_fd_sc_hd__and2_1
X_6675_ _3387_ VGND VGND VPWR VPWR _3388_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_45_244 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5626_ _2667_ _2817_ VGND VGND VPWR VPWR _2825_ sky130_fd_sc_hd__and2_1
XFILLER_0_91_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_73_586 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_60_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3887_ _1390_ _1569_ _1571_ _1573_ _1403_ VGND VGND VPWR VPWR _1574_ sky130_fd_sc_hd__a221o_1
XFILLER_0_116_677 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_26_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_103_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_103_316 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_13_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5488_ _2451_ _2775_ VGND VGND VPWR VPWR _2777_ sky130_fd_sc_hd__nor2_4
X_4508_ _2164_ _2165_ _1903_ VGND VGND VPWR VPWR _2166_ sky130_fd_sc_hd__mux2_1
X_4439_ _1811_ VGND VGND VPWR VPWR _2101_ sky130_fd_sc_hd__clkbuf_4
X_7227_ clknet_leaf_90_clk _0818_ VGND VGND VPWR VPWR memory\[31\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_111_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_111_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7158_ clknet_leaf_104_clk _0749_ VGND VGND VPWR VPWR memory\[2\]\[7\] sky130_fd_sc_hd__dfxtp_1
XTAP_391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6109_ _3005_ VGND VGND VPWR VPWR _3104_ sky130_fd_sc_hd__clkbuf_4
X_7089_ clknet_leaf_3_clk _0680_ VGND VGND VPWR VPWR memory\[29\]\[2\] sky130_fd_sc_hd__dfxtp_1
XTAP_1524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_119_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_122_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_47_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_2_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_59_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4790_ _1876_ _2432_ _1880_ VGND VGND VPWR VPWR _2433_ sky130_fd_sc_hd__o21a_1
X_3810_ _1186_ _1500_ VGND VGND VPWR VPWR _1501_ sky130_fd_sc_hd__or2_1
XFILLER_0_7_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XANTENNA_29 _2529_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_18 _1844_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3741_ _1435_ VGND VGND VPWR VPWR _0002_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_82_350 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_12_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3672_ _1250_ _1369_ _1254_ VGND VGND VPWR VPWR _1370_ sky130_fd_sc_hd__o21a_1
XFILLER_0_12_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6460_ net781 _3291_ _3280_ _3292_ VGND VGND VPWR VPWR _0237_ sky130_fd_sc_hd__a31o_1
XFILLER_0_42_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6391_ _2861_ _3251_ VGND VGND VPWR VPWR _3253_ sky130_fd_sc_hd__and2_1
XFILLER_0_2_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5411_ _2456_ _2758_ _2760_ net336 VGND VGND VPWR VPWR _0745_ sky130_fd_sc_hd__a22o_1
XFILLER_0_113_658 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput103 net103 VGND VGND VPWR VPWR data_out2[29] sky130_fd_sc_hd__clkbuf_4
X_5342_ _2470_ _2742_ _2743_ net451 VGND VGND VPWR VPWR _0693_ sky130_fd_sc_hd__a22o_1
XFILLER_0_10_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7012_ clknet_leaf_31_clk _0603_ VGND VGND VPWR VPWR memory\[26\]\[21\] sky130_fd_sc_hd__dfxtp_1
X_5273_ net601 _2704_ _2707_ _2710_ VGND VGND VPWR VPWR _0657_ sky130_fd_sc_hd__a31o_1
X_4224_ _1871_ _1895_ VGND VGND VPWR VPWR _1896_ sky130_fd_sc_hd__or2_1
X_4155_ _1811_ VGND VGND VPWR VPWR _1829_ sky130_fd_sc_hd__buf_4
X_4086_ memory\[20\]\[30\] memory\[21\]\[30\] memory\[22\]\[30\] memory\[23\]\[30\]
+ _1240_ _1241_ VGND VGND VPWR VPWR _1762_ sky130_fd_sc_hd__mux4_1
X_7914_ clknet_leaf_32_clk _0448_ VGND VGND VPWR VPWR memory\[17\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_78_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7845_ clknet_leaf_57_clk _0379_ VGND VGND VPWR VPWR memory\[9\]\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_93_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_108_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_659 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4988_ _2529_ VGND VGND VPWR VPWR _2543_ sky130_fd_sc_hd__clkbuf_4
X_7776_ clknet_leaf_101_clk _0310_ VGND VGND VPWR VPWR memory\[30\]\[17\] sky130_fd_sc_hd__dfxtp_1
X_6727_ net865 _3406_ _3413_ _3417_ VGND VGND VPWR VPWR _0379_ sky130_fd_sc_hd__a31o_1
X_3939_ _1618_ _1620_ _1623_ _1154_ _1606_ VGND VGND VPWR VPWR _1624_ sky130_fd_sc_hd__a221o_1
XFILLER_0_80_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_0__2786_ _2786_ VGND VGND VPWR VPWR clknet_0__2786_ sky130_fd_sc_hd__clkbuf_16
X_6658_ _3378_ VGND VGND VPWR VPWR _3383_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_103_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5609_ _2650_ _2804_ VGND VGND VPWR VPWR _2815_ sky130_fd_sc_hd__and2_1
X_6589_ _2489_ _2446_ _2501_ VGND VGND VPWR VPWR _3366_ sky130_fd_sc_hd__and3_1
XFILLER_0_14_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_112_680 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_69_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput27 data_in[1] VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__clkbuf_4
Xinput16 data_in[0] VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__buf_2
Xinput49 w_enable VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__clkbuf_2
Xinput38 data_in[2] VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_24_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_122_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_20_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5960_ _2851_ _3010_ VGND VGND VPWR VPWR _3018_ sky130_fd_sc_hd__and2_1
X_4911_ _2495_ VGND VGND VPWR VPWR _2500_ sky130_fd_sc_hd__clkbuf_4
X_5891_ _2964_ VGND VGND VPWR VPWR _2978_ sky130_fd_sc_hd__buf_2
XFILLER_0_90_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7630_ clknet_leaf_19_clk _0164_ VGND VGND VPWR VPWR memory\[27\]\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_114_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4842_ net21 VGND VGND VPWR VPWR _2469_ sky130_fd_sc_hd__buf_4
X_7561_ clknet_leaf_24_clk _1120_ VGND VGND VPWR VPWR memory\[20\]\[26\] sky130_fd_sc_hd__dfxtp_1
X_4773_ _1829_ _2416_ VGND VGND VPWR VPWR _2417_ sky130_fd_sc_hd__or2_1
XFILLER_0_62_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7492_ clknet_leaf_27_clk _1051_ VGND VGND VPWR VPWR memory\[24\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_99_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6512_ net402 _3317_ _3279_ _3321_ VGND VGND VPWR VPWR _0260_ sky130_fd_sc_hd__a31o_1
X_3724_ _1394_ _1418_ VGND VGND VPWR VPWR _1419_ sky130_fd_sc_hd__or2_1
XFILLER_0_43_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6443_ net979 _3275_ _3280_ _3283_ VGND VGND VPWR VPWR _0229_ sky130_fd_sc_hd__a31o_1
X_3655_ _1187_ VGND VGND VPWR VPWR _1353_ sky130_fd_sc_hd__buf_4
XFILLER_0_3_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_101_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6374_ _2845_ _3238_ VGND VGND VPWR VPWR _3243_ sky130_fd_sc_hd__and2_1
XFILLER_0_3_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_2_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3586_ _1286_ _1287_ _1243_ VGND VGND VPWR VPWR _1288_ sky130_fd_sc_hd__mux2_1
XFILLER_0_100_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5325_ _2439_ _2739_ _2741_ net230 VGND VGND VPWR VPWR _0678_ sky130_fd_sc_hd__a22o_1
X_5256_ net866 _2675_ _2693_ _2700_ VGND VGND VPWR VPWR _0650_ sky130_fd_sc_hd__a31o_1
XFILLER_0_54_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4207_ _1796_ VGND VGND VPWR VPWR _1880_ sky130_fd_sc_hd__buf_4
XFILLER_0_48_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5187_ _2671_ _2655_ VGND VGND VPWR VPWR _2672_ sky130_fd_sc_hd__and2_1
X_4138_ _1811_ VGND VGND VPWR VPWR _1812_ sky130_fd_sc_hd__buf_4
X_4069_ memory\[16\]\[29\] memory\[17\]\[29\] memory\[18\]\[29\] memory\[19\]\[29\]
+ _1157_ _1159_ VGND VGND VPWR VPWR _1746_ sky130_fd_sc_hd__mux4_1
X_7828_ clknet_leaf_12_clk _0362_ VGND VGND VPWR VPWR memory\[9\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_74_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7759_ clknet_leaf_5_clk _0293_ VGND VGND VPWR VPWR memory\[30\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_34_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_84_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_121_7 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_115_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_107_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold608 memory\[1\]\[20\] VGND VGND VPWR VPWR net817 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_110_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold619 memory\[4\]\[17\] VGND VGND VPWR VPWR net828 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_20_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6090_ _2905_ _3052_ VGND VGND VPWR VPWR _3092_ sky130_fd_sc_hd__and2_1
XFILLER_0_85_13 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5110_ net989 _2601_ _2606_ _2618_ VGND VGND VPWR VPWR _0586_ sky130_fd_sc_hd__a31o_1
XTAP_902 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_913 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_924 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_935 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_109_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_968 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5041_ net1114 _2572_ _2573_ VGND VGND VPWR VPWR _2575_ sky130_fd_sc_hd__and3_1
XTAP_957 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_946 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_979 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6992_ clknet_leaf_4_clk _0583_ VGND VGND VPWR VPWR memory\[26\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_5943_ _3007_ VGND VGND VPWR VPWR _3008_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_87_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5874_ _2840_ _2965_ VGND VGND VPWR VPWR _2969_ sky130_fd_sc_hd__and2_1
XFILLER_0_118_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4825_ _2459_ _2449_ _2453_ net974 VGND VGND VPWR VPWR _0459_ sky130_fd_sc_hd__a22o_1
X_7613_ clknet_leaf_96_clk _0147_ VGND VGND VPWR VPWR memory\[27\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_47_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7544_ clknet_leaf_109_clk _1103_ VGND VGND VPWR VPWR memory\[20\]\[9\] sky130_fd_sc_hd__dfxtp_1
X_4756_ memory\[12\]\[29\] memory\[13\]\[29\] memory\[14\]\[29\] memory\[15\]\[29\]
+ _1965_ _1966_ VGND VGND VPWR VPWR _2401_ sky130_fd_sc_hd__mux4_1
XFILLER_0_50_71 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4687_ _2327_ _2335_ VGND VGND VPWR VPWR _2336_ sky130_fd_sc_hd__and2_1
X_7475_ clknet_leaf_0_clk _1034_ VGND VGND VPWR VPWR memory\[24\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_3707_ _1183_ VGND VGND VPWR VPWR _1403_ sky130_fd_sc_hd__clkbuf_4
X_6426_ _2897_ _3264_ VGND VGND VPWR VPWR _3272_ sky130_fd_sc_hd__and2_1
X_3638_ _1177_ _1336_ _1181_ VGND VGND VPWR VPWR _1337_ sky130_fd_sc_hd__o21a_1
XFILLER_0_101_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6357_ _2673_ _3231_ _3232_ net388 VGND VGND VPWR VPWR _0194_ sky130_fd_sc_hd__a22o_1
X_3569_ _1189_ VGND VGND VPWR VPWR _1272_ sky130_fd_sc_hd__clkbuf_8
X_5308_ net1061 _2717_ _2720_ _2729_ VGND VGND VPWR VPWR _0673_ sky130_fd_sc_hd__a31o_1
X_6288_ _2876_ _3197_ VGND VGND VPWR VPWR _3207_ sky130_fd_sc_hd__and2_1
X_5239_ _2487_ _2682_ _2684_ net426 VGND VGND VPWR VPWR _0644_ sky130_fd_sc_hd__a22o_1
XPHY_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_637 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_39_659 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_120_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_1_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold5 memory\[16\]\[0\] VGND VGND VPWR VPWR net214 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_76_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4610_ memory\[8\]\[21\] memory\[9\]\[21\] memory\[10\]\[21\] memory\[11\]\[21\]
+ _1837_ _1838_ VGND VGND VPWR VPWR _2263_ sky130_fd_sc_hd__mux4_1
XFILLER_0_44_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_115_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5590_ _2631_ _2804_ VGND VGND VPWR VPWR _2805_ sky130_fd_sc_hd__and2_1
XFILLER_0_20_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4541_ _2188_ _2197_ VGND VGND VPWR VPWR _2198_ sky130_fd_sc_hd__and2_1
XFILLER_0_53_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold416 memory\[19\]\[23\] VGND VGND VPWR VPWR net625 sky130_fd_sc_hd__dlygate4sd3_1
X_7260_ net163 _0004_ VGND VGND VPWR VPWR net86 sky130_fd_sc_hd__dfxtp_2
Xhold427 memory\[21\]\[14\] VGND VGND VPWR VPWR net636 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_20_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold405 memory\[29\]\[18\] VGND VGND VPWR VPWR net614 sky130_fd_sc_hd__dlygate4sd3_1
X_4472_ memory\[28\]\[14\] memory\[29\]\[14\] memory\[30\]\[14\] memory\[31\]\[14\]
+ _1965_ _1966_ VGND VGND VPWR VPWR _2132_ sky130_fd_sc_hd__mux4_1
XFILLER_0_52_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold449 memory\[12\]\[13\] VGND VGND VPWR VPWR net658 sky130_fd_sc_hd__dlygate4sd3_1
X_7191_ clknet_leaf_22_clk _0782_ VGND VGND VPWR VPWR memory\[14\]\[8\] sky130_fd_sc_hd__dfxtp_1
Xhold438 memory\[23\]\[0\] VGND VGND VPWR VPWR net647 sky130_fd_sc_hd__dlygate4sd3_1
X_6211_ _2874_ _3154_ VGND VGND VPWR VPWR _3163_ sky130_fd_sc_hd__and2_1
X_6142_ _3096_ VGND VGND VPWR VPWR _3123_ sky130_fd_sc_hd__buf_2
XFILLER_0_0_464 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_110_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6073_ _2888_ _3079_ VGND VGND VPWR VPWR _3083_ sky130_fd_sc_hd__and2_1
XTAP_754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_765 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_776 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5024_ net1105 _2557_ _2560_ VGND VGND VPWR VPWR _2565_ sky130_fd_sc_hd__and3_1
XTAP_787 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_798 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6975_ clknet_leaf_84_clk _0566_ VGND VGND VPWR VPWR memory\[6\]\[16\] sky130_fd_sc_hd__dfxtp_1
X_5926_ _2893_ _2991_ VGND VGND VPWR VPWR _2998_ sky130_fd_sc_hd__and2_1
X_5539__15 clknet_1_1__leaf__2785_ VGND VGND VPWR VPWR net160 sky130_fd_sc_hd__inv_2
X_5857_ net1117 _2600_ _2947_ VGND VGND VPWR VPWR _2957_ sky130_fd_sc_hd__and3_1
XFILLER_0_75_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4808_ net48 VGND VGND VPWR VPWR _0517_ sky130_fd_sc_hd__inv_2
X_5788_ _2510_ _2603_ _2736_ VGND VGND VPWR VPWR _2917_ sky130_fd_sc_hd__and3_1
XFILLER_0_44_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7527_ clknet_leaf_51_clk _1086_ VGND VGND VPWR VPWR memory\[11\]\[24\] sky130_fd_sc_hd__dfxtp_1
X_4739_ _2383_ _2384_ _1809_ VGND VGND VPWR VPWR _2385_ sky130_fd_sc_hd__mux2_1
X_5554__29 clknet_1_0__leaf__2786_ VGND VGND VPWR VPWR net174 sky130_fd_sc_hd__inv_2
XFILLER_0_43_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_102_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_7458_ clknet_leaf_68_clk _1017_ VGND VGND VPWR VPWR memory\[1\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_31_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6409_ _3145_ VGND VGND VPWR VPWR _3262_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_101_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold961 memory\[6\]\[21\] VGND VGND VPWR VPWR net1170 sky130_fd_sc_hd__dlygate4sd3_1
X_7389_ clknet_leaf_91_clk _0948_ VGND VGND VPWR VPWR memory\[25\]\[14\] sky130_fd_sc_hd__dfxtp_1
Xhold950 memory\[25\]\[6\] VGND VGND VPWR VPWR net1159 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_39_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_81_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_105_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_239 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_66_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6760_ _2627_ _3429_ _3431_ net1053 VGND VGND VPWR VPWR _0398_ sky130_fd_sc_hd__a22o_1
X_3972_ _1483_ _1654_ VGND VGND VPWR VPWR _1655_ sky130_fd_sc_hd__or2_1
X_5711_ net939 _2867_ _2880_ _2883_ VGND VGND VPWR VPWR _0890_ sky130_fd_sc_hd__a31o_1
XFILLER_0_85_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6691_ net45 _3388_ VGND VGND VPWR VPWR _3397_ sky130_fd_sc_hd__and2_1
XFILLER_0_122_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5642_ _2510_ _2490_ _2558_ VGND VGND VPWR VPWR _2835_ sky130_fd_sc_hd__and3_2
X_5573_ _2615_ _2791_ VGND VGND VPWR VPWR _2795_ sky130_fd_sc_hd__and2_1
XFILLER_0_25_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_103_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold202 memory\[7\]\[30\] VGND VGND VPWR VPWR net411 sky130_fd_sc_hd__dlygate4sd3_1
X_7312_ clknet_leaf_103_clk _0871_ VGND VGND VPWR VPWR memory\[7\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_4524_ memory\[24\]\[17\] memory\[25\]\[17\] memory\[26\]\[17\] memory\[27\]\[17\]
+ _1872_ _1873_ VGND VGND VPWR VPWR _2181_ sky130_fd_sc_hd__mux4_1
XFILLER_0_53_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold213 memory\[29\]\[25\] VGND VGND VPWR VPWR net422 sky130_fd_sc_hd__dlygate4sd3_1
Xhold235 memory\[16\]\[21\] VGND VGND VPWR VPWR net444 sky130_fd_sc_hd__dlygate4sd3_1
Xhold224 memory\[1\]\[16\] VGND VGND VPWR VPWR net433 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7243_ clknet_leaf_35_clk _0834_ VGND VGND VPWR VPWR memory\[31\]\[28\] sky130_fd_sc_hd__dfxtp_1
X_4455_ _1819_ VGND VGND VPWR VPWR _2116_ sky130_fd_sc_hd__buf_4
Xhold246 memory\[2\]\[11\] VGND VGND VPWR VPWR net455 sky130_fd_sc_hd__dlygate4sd3_1
Xhold257 memory\[20\]\[15\] VGND VGND VPWR VPWR net466 sky130_fd_sc_hd__dlygate4sd3_1
Xhold268 memory\[1\]\[12\] VGND VGND VPWR VPWR net477 sky130_fd_sc_hd__dlygate4sd3_1
X_7174_ clknet_leaf_57_clk _0765_ VGND VGND VPWR VPWR memory\[2\]\[23\] sky130_fd_sc_hd__dfxtp_1
Xhold279 memory\[26\]\[18\] VGND VGND VPWR VPWR net488 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4386_ _2050_ VGND VGND VPWR VPWR _0063_ sky130_fd_sc_hd__buf_1
X_6125_ net667 _3104_ _3109_ _3113_ VGND VGND VPWR VPWR _1106_ sky130_fd_sc_hd__a31o_1
XTAP_540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6056_ _2872_ _3066_ VGND VGND VPWR VPWR _3073_ sky130_fd_sc_hd__and2_1
X_5007_ memory\[10\]\[31\] _2543_ _2512_ VGND VGND VPWR VPWR _2553_ sky130_fd_sc_hd__and3_1
XTAP_1706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_119 _2861_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_108 _1978_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_1739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6958_ clknet_leaf_42_clk _0549_ VGND VGND VPWR VPWR memory\[10\]\[31\] sky130_fd_sc_hd__dfxtp_1
X_6889_ clknet_leaf_34_clk _0480_ VGND VGND VPWR VPWR memory\[28\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_91_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5909_ _2876_ _2978_ VGND VGND VPWR VPWR _2988_ sky130_fd_sc_hd__and2_1
XFILLER_0_106_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_114_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_102_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold791 memory\[16\]\[18\] VGND VGND VPWR VPWR net1000 sky130_fd_sc_hd__dlygate4sd3_1
Xhold780 memory\[26\]\[4\] VGND VGND VPWR VPWR net989 sky130_fd_sc_hd__dlygate4sd3_1
Xclkbuf_1_1__f__2783_ clknet_0__2783_ VGND VGND VPWR VPWR clknet_1_1__leaf__2783_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_36_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_99_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_716 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_112_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4240_ memory\[0\]\[3\] memory\[1\]\[3\] memory\[2\]\[3\] memory\[3\]\[3\] _1866_
+ _1867_ VGND VGND VPWR VPWR _1911_ sky130_fd_sc_hd__mux4_1
X_4171_ _1799_ VGND VGND VPWR VPWR _1845_ sky130_fd_sc_hd__buf_6
X_7930_ net193 _0034_ VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__dfxtp_2
XFILLER_0_89_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7861_ clknet_leaf_21_clk _0395_ VGND VGND VPWR VPWR memory\[13\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_77_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6812_ _2648_ _3441_ _3442_ net271 VGND VGND VPWR VPWR _0439_ sky130_fd_sc_hd__a22o_1
X_7792_ clknet_leaf_23_clk _0326_ VGND VGND VPWR VPWR memory\[12\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_3955_ memory\[12\]\[22\] memory\[13\]\[22\] memory\[14\]\[22\] memory\[15\]\[22\]
+ _1430_ _1431_ VGND VGND VPWR VPWR _1639_ sky130_fd_sc_hd__mux4_1
X_6743_ net566 _2509_ _3385_ _3425_ VGND VGND VPWR VPWR _0387_ sky130_fd_sc_hd__a31o_1
XFILLER_0_18_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_116_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6674_ _2690_ _2511_ _2736_ VGND VGND VPWR VPWR _3387_ sky130_fd_sc_hd__and3_2
XFILLER_0_9_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_116_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5625_ _2730_ VGND VGND VPWR VPWR _2824_ sky130_fd_sc_hd__buf_4
XFILLER_0_61_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3886_ _1397_ _1572_ _1401_ VGND VGND VPWR VPWR _1573_ sky130_fd_sc_hd__o21a_1
XFILLER_0_45_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_116_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_73_598 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_26_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_103_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5487_ _2775_ VGND VGND VPWR VPWR _2776_ sky130_fd_sc_hd__clkbuf_4
X_4507_ memory\[16\]\[16\] memory\[17\]\[16\] memory\[18\]\[16\] memory\[19\]\[16\]
+ _2028_ _2029_ VGND VGND VPWR VPWR _2165_ sky130_fd_sc_hd__mux4_1
X_7226_ clknet_leaf_78_clk _0817_ VGND VGND VPWR VPWR memory\[31\]\[11\] sky130_fd_sc_hd__dfxtp_1
X_4438_ _2098_ _2099_ _1869_ VGND VGND VPWR VPWR _2100_ sky130_fd_sc_hd__mux2_1
XFILLER_0_6_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4369_ memory\[24\]\[9\] memory\[25\]\[9\] memory\[26\]\[9\] memory\[27\]\[9\] _2032_
+ _2033_ VGND VGND VPWR VPWR _2034_ sky130_fd_sc_hd__mux4_1
X_7157_ clknet_leaf_103_clk _0748_ VGND VGND VPWR VPWR memory\[2\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_6108_ net718 _3088_ _3095_ _3103_ VGND VGND VPWR VPWR _1099_ sky130_fd_sc_hd__a31o_1
XTAP_392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7088_ clknet_leaf_6_clk _0679_ VGND VGND VPWR VPWR memory\[29\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_6039_ net583 _3062_ _3051_ _3063_ VGND VGND VPWR VPWR _1070_ sky130_fd_sc_hd__a31o_1
XTAP_1514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_leaf_115_clk clknet_4_0_0_clk VGND VGND VPWR VPWR clknet_leaf_115_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_64_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_121_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_20_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_99_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_19 _1909_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_106_clk clknet_4_1_0_clk VGND VGND VPWR VPWR clknet_leaf_106_clk sky130_fd_sc_hd__clkbuf_16
X_3740_ _1422_ _1434_ VGND VGND VPWR VPWR _1435_ sky130_fd_sc_hd__and2_1
XFILLER_0_82_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_12_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_43_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3671_ memory\[12\]\[8\] memory\[13\]\[8\] memory\[14\]\[8\] memory\[15\]\[8\] _1251_
+ _1252_ VGND VGND VPWR VPWR _1369_ sky130_fd_sc_hd__mux4_1
X_6390_ net500 _3249_ _3250_ _3252_ VGND VGND VPWR VPWR _0207_ sky130_fd_sc_hd__a31o_1
X_5410_ _2455_ _2758_ _2760_ net319 VGND VGND VPWR VPWR _0744_ sky130_fd_sc_hd__a22o_1
Xoutput104 net104 VGND VGND VPWR VPWR data_out2[2] sky130_fd_sc_hd__clkbuf_4
X_5341_ _2469_ _2742_ _2743_ net508 VGND VGND VPWR VPWR _0692_ sky130_fd_sc_hd__a22o_1
XFILLER_0_112_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7011_ clknet_leaf_30_clk _0602_ VGND VGND VPWR VPWR memory\[26\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_10_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5272_ _2634_ _2708_ VGND VGND VPWR VPWR _2710_ sky130_fd_sc_hd__and2_1
X_4223_ memory\[8\]\[2\] memory\[9\]\[2\] memory\[10\]\[2\] memory\[11\]\[2\] _1872_
+ _1873_ VGND VGND VPWR VPWR _1895_ sky130_fd_sc_hd__mux4_1
X_4154_ _1798_ _1810_ _1818_ _1825_ _1827_ VGND VGND VPWR VPWR _1828_ sky130_fd_sc_hd__a221o_1
X_4085_ _1761_ VGND VGND VPWR VPWR _0021_ sky130_fd_sc_hd__clkbuf_1
X_7913_ clknet_leaf_31_clk _0447_ VGND VGND VPWR VPWR memory\[17\]\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_78_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7844_ clknet_leaf_55_clk _0378_ VGND VGND VPWR VPWR memory\[9\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_77_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7775_ clknet_leaf_86_clk _0309_ VGND VGND VPWR VPWR memory\[30\]\[16\] sky130_fd_sc_hd__dfxtp_1
X_6726_ net30 _3414_ VGND VGND VPWR VPWR _3417_ sky130_fd_sc_hd__and2_1
X_4987_ _2478_ _2539_ _2542_ VGND VGND VPWR VPWR _0539_ sky130_fd_sc_hd__a21o_1
XFILLER_0_46_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3938_ _1621_ _1622_ _1166_ VGND VGND VPWR VPWR _1623_ sky130_fd_sc_hd__mux2_1
Xclkbuf_0__2785_ _2785_ VGND VGND VPWR VPWR clknet_0__2785_ sky130_fd_sc_hd__clkbuf_16
X_6657_ _3376_ VGND VGND VPWR VPWR _3382_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_73_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3869_ _1390_ _1550_ _1554_ _1556_ _1403_ VGND VGND VPWR VPWR _1557_ sky130_fd_sc_hd__a221o_1
X_5608_ net1025 _2811_ _2803_ _2814_ VGND VGND VPWR VPWR _0856_ sky130_fd_sc_hd__a31o_1
X_6588_ net382 _3359_ _3323_ _3365_ VGND VGND VPWR VPWR _0292_ sky130_fd_sc_hd__a31o_1
XFILLER_0_33_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_4_2_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_2_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_112_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7209_ clknet_leaf_53_clk _0800_ VGND VGND VPWR VPWR memory\[14\]\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_96_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput17 data_in[10] VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__buf_2
Xinput28 data_in[20] VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__buf_4
XFILLER_0_3_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput39 data_in[30] VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_24_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_122_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_103_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_58_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_99_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_87_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4910_ _2493_ VGND VGND VPWR VPWR _2499_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_87_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5890_ _2962_ VGND VGND VPWR VPWR _2977_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_90_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_59_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4841_ _2468_ _2464_ _2465_ net1001 VGND VGND VPWR VPWR _0466_ sky130_fd_sc_hd__a22o_1
X_7560_ clknet_leaf_25_clk _1119_ VGND VGND VPWR VPWR memory\[20\]\[25\] sky130_fd_sc_hd__dfxtp_1
X_4772_ memory\[8\]\[30\] memory\[9\]\[30\] memory\[10\]\[30\] memory\[11\]\[30\]
+ _1837_ _1838_ VGND VGND VPWR VPWR _2416_ sky130_fd_sc_hd__mux4_1
XFILLER_0_83_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7491_ clknet_leaf_29_clk _1050_ VGND VGND VPWR VPWR memory\[24\]\[20\] sky130_fd_sc_hd__dfxtp_1
X_6511_ _2905_ _3281_ VGND VGND VPWR VPWR _3321_ sky130_fd_sc_hd__and2_1
Xclkbuf_1_0__f__3446_ clknet_0__3446_ VGND VGND VPWR VPWR clknet_1_0__leaf__3446_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_55_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3723_ memory\[24\]\[11\] memory\[25\]\[11\] memory\[26\]\[11\] memory\[27\]\[11\]
+ _1353_ _1354_ VGND VGND VPWR VPWR _1418_ sky130_fd_sc_hd__mux4_1
XFILLER_0_70_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6442_ _2834_ _3282_ VGND VGND VPWR VPWR _3283_ sky130_fd_sc_hd__and2_1
X_3654_ _1348_ _1351_ _1279_ VGND VGND VPWR VPWR _1352_ sky130_fd_sc_hd__mux2_1
XFILLER_0_113_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6373_ net790 _3233_ _3236_ _3242_ VGND VGND VPWR VPWR _0200_ sky130_fd_sc_hd__a31o_1
XFILLER_0_23_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3585_ memory\[0\]\[4\] memory\[1\]\[4\] memory\[2\]\[4\] memory\[3\]\[4\] _1240_
+ _1241_ VGND VGND VPWR VPWR _1287_ sky130_fd_sc_hd__mux4_1
X_5324_ _2740_ VGND VGND VPWR VPWR _2741_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_2_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5255_ _2617_ _2695_ VGND VGND VPWR VPWR _2700_ sky130_fd_sc_hd__and2_1
X_4206_ memory\[12\]\[1\] memory\[13\]\[1\] memory\[14\]\[1\] memory\[15\]\[1\] _1877_
+ _1878_ VGND VGND VPWR VPWR _1879_ sky130_fd_sc_hd__mux4_2
X_5186_ net36 VGND VGND VPWR VPWR _2671_ sky130_fd_sc_hd__buf_4
X_6853__60 clknet_1_1__leaf__3446_ VGND VGND VPWR VPWR net205 sky130_fd_sc_hd__inv_2
X_4137_ net3 VGND VGND VPWR VPWR _1811_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_3_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4068_ memory\[20\]\[29\] memory\[21\]\[29\] memory\[22\]\[29\] memory\[23\]\[29\]
+ _1240_ _1241_ VGND VGND VPWR VPWR _1745_ sky130_fd_sc_hd__mux4_1
XFILLER_0_38_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7827_ clknet_leaf_9_clk _0361_ VGND VGND VPWR VPWR memory\[9\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_93_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7758_ clknet_leaf_8_clk _0292_ VGND VGND VPWR VPWR memory\[22\]\[31\] sky130_fd_sc_hd__dfxtp_1
X_7689_ clknet_leaf_24_clk _0223_ VGND VGND VPWR VPWR memory\[21\]\[26\] sky130_fd_sc_hd__dfxtp_1
X_6709_ net721 _3406_ _3400_ _3407_ VGND VGND VPWR VPWR _0371_ sky130_fd_sc_hd__a31o_1
XFILLER_0_116_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_116_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_52_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_122_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold609 memory\[7\]\[0\] VGND VGND VPWR VPWR net818 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_549 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_110_437 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_85_25 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_0_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_903 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_914 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_925 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5040_ _2463_ _2571_ _2574_ VGND VGND VPWR VPWR _0560_ sky130_fd_sc_hd__a21o_1
XTAP_936 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_958 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_947 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_969 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6991_ clknet_leaf_4_clk _0582_ VGND VGND VPWR VPWR memory\[26\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_5942_ _2691_ _2603_ VGND VGND VPWR VPWR _3007_ sky130_fd_sc_hd__nand2_4
XFILLER_0_75_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_8_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5873_ _2730_ VGND VGND VPWR VPWR _2968_ sky130_fd_sc_hd__buf_4
X_7612_ clknet_leaf_96_clk _0146_ VGND VGND VPWR VPWR memory\[27\]\[13\] sky130_fd_sc_hd__dfxtp_1
X_4824_ net44 VGND VGND VPWR VPWR _2459_ sky130_fd_sc_hd__buf_4
X_4755_ _1829_ _2399_ VGND VGND VPWR VPWR _2400_ sky130_fd_sc_hd__or2_1
XFILLER_0_90_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7543_ clknet_leaf_110_clk _1102_ VGND VGND VPWR VPWR memory\[20\]\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_28_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3706_ _1397_ _1400_ _1401_ VGND VGND VPWR VPWR _1402_ sky130_fd_sc_hd__o21a_1
XFILLER_0_50_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4686_ _2329_ _2331_ _2334_ _1797_ _2249_ VGND VGND VPWR VPWR _2335_ sky130_fd_sc_hd__a221o_1
X_7474_ clknet_leaf_2_clk _1033_ VGND VGND VPWR VPWR memory\[24\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_6425_ net819 _3262_ _3263_ _3271_ VGND VGND VPWR VPWR _0223_ sky130_fd_sc_hd__a31o_1
X_3637_ memory\[28\]\[7\] memory\[29\]\[7\] memory\[30\]\[7\] memory\[31\]\[7\] _1178_
+ _1179_ VGND VGND VPWR VPWR _1336_ sky130_fd_sc_hd__mux4_1
XFILLER_0_113_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6356_ _2671_ _3231_ _3232_ net233 VGND VGND VPWR VPWR _0193_ sky130_fd_sc_hd__a22o_1
X_3568_ _1187_ VGND VGND VPWR VPWR _1271_ sky130_fd_sc_hd__buf_8
X_5307_ _2669_ _2721_ VGND VGND VPWR VPWR _2729_ sky130_fd_sc_hd__and2_1
XFILLER_0_11_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3499_ _1165_ VGND VGND VPWR VPWR _1205_ sky130_fd_sc_hd__clkbuf_8
X_6287_ net941 _3200_ _3196_ _3206_ VGND VGND VPWR VPWR _0150_ sky130_fd_sc_hd__a31o_1
X_5238_ _2486_ _2688_ _2689_ net240 VGND VGND VPWR VPWR _0643_ sky130_fd_sc_hd__a22o_1
X_5169_ _2659_ _2655_ VGND VGND VPWR VPWR _2660_ sky130_fd_sc_hd__and2_1
Xclkbuf_leaf_95_clk clknet_4_4_0_clk VGND VGND VPWR VPWR clknet_leaf_95_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_78_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_120_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_104_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold6 memory\[31\]\[31\] VGND VGND VPWR VPWR net215 sky130_fd_sc_hd__dlygate4sd3_1
Xclkbuf_leaf_86_clk clknet_4_7_0_clk VGND VGND VPWR VPWR clknet_leaf_86_clk sky130_fd_sc_hd__clkbuf_16
X_6832__41 clknet_1_1__leaf__2787_ VGND VGND VPWR VPWR net186 sky130_fd_sc_hd__inv_2
XFILLER_0_5_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_111_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4540_ _2097_ _2192_ _2194_ _2196_ _2066_ VGND VGND VPWR VPWR _2197_ sky130_fd_sc_hd__a221o_1
Xclkbuf_leaf_10_clk clknet_4_3_0_clk VGND VGND VPWR VPWR clknet_leaf_10_clk sky130_fd_sc_hd__clkbuf_16
Xhold417 memory\[30\]\[7\] VGND VGND VPWR VPWR net626 sky130_fd_sc_hd__dlygate4sd3_1
Xhold406 memory\[19\]\[7\] VGND VGND VPWR VPWR net615 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_20_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4471_ _1959_ _2130_ VGND VGND VPWR VPWR _2131_ sky130_fd_sc_hd__or2_1
Xhold439 memory\[20\]\[26\] VGND VGND VPWR VPWR net648 sky130_fd_sc_hd__dlygate4sd3_1
X_7190_ clknet_leaf_7_clk _0781_ VGND VGND VPWR VPWR memory\[14\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_6210_ net350 _3159_ _3153_ _3162_ VGND VGND VPWR VPWR _1142_ sky130_fd_sc_hd__a31o_1
XFILLER_0_0_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold428 memory\[24\]\[10\] VGND VGND VPWR VPWR net637 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6141_ _3094_ VGND VGND VPWR VPWR _3122_ sky130_fd_sc_hd__clkbuf_4
XTAP_700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6072_ net702 _3075_ _3078_ _3082_ VGND VGND VPWR VPWR _1084_ sky130_fd_sc_hd__a31o_1
XTAP_744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_766 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_777 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5023_ _2456_ _2556_ _2564_ VGND VGND VPWR VPWR _0553_ sky130_fd_sc_hd__a21o_1
XTAP_788 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_799 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_77_clk clknet_4_6_0_clk VGND VGND VPWR VPWR clknet_leaf_77_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_45_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6974_ clknet_leaf_85_clk _0565_ VGND VGND VPWR VPWR memory\[6\]\[15\] sky130_fd_sc_hd__dfxtp_1
X_5925_ net830 _2994_ _2990_ _2997_ VGND VGND VPWR VPWR _1022_ sky130_fd_sc_hd__a31o_1
X_5856_ _2485_ _2946_ _2956_ VGND VGND VPWR VPWR _0962_ sky130_fd_sc_hd__a21o_1
XFILLER_0_0_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4807_ _2448_ VGND VGND VPWR VPWR _2449_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_8_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5787_ _2678_ _2909_ _2911_ net641 VGND VGND VPWR VPWR _0933_ sky130_fd_sc_hd__a22o_1
XFILLER_0_56_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7526_ clknet_leaf_54_clk _1085_ VGND VGND VPWR VPWR memory\[11\]\[23\] sky130_fd_sc_hd__dfxtp_1
X_4738_ memory\[0\]\[28\] memory\[1\]\[28\] memory\[2\]\[28\] memory\[3\]\[28\] _1842_
+ _1843_ VGND VGND VPWR VPWR _2384_ sky130_fd_sc_hd__mux4_1
X_4669_ _2310_ _2318_ VGND VGND VPWR VPWR _2319_ sky130_fd_sc_hd__and2_1
X_7457_ clknet_leaf_69_clk _1016_ VGND VGND VPWR VPWR memory\[1\]\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_114_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_102_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6408_ net1010 _3249_ _3250_ _3261_ VGND VGND VPWR VPWR _0216_ sky130_fd_sc_hd__a31o_1
Xhold940 memory\[6\]\[17\] VGND VGND VPWR VPWR net1149 sky130_fd_sc_hd__dlygate4sd3_1
Xhold951 memory\[10\]\[18\] VGND VGND VPWR VPWR net1160 sky130_fd_sc_hd__dlygate4sd3_1
X_7388_ clknet_leaf_87_clk _0947_ VGND VGND VPWR VPWR memory\[25\]\[13\] sky130_fd_sc_hd__dfxtp_1
Xhold962 memory\[6\]\[2\] VGND VGND VPWR VPWR net1171 sky130_fd_sc_hd__dlygate4sd3_1
X_6339_ _2638_ _3229_ _3230_ net622 VGND VGND VPWR VPWR _0178_ sky130_fd_sc_hd__a22o_1
Xclkbuf_leaf_68_clk clknet_4_13_0_clk VGND VGND VPWR VPWR clknet_leaf_68_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_98_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_66_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_59_clk clknet_4_15_0_clk VGND VGND VPWR VPWR clknet_leaf_59_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3971_ memory\[8\]\[23\] memory\[9\]\[23\] memory\[10\]\[23\] memory\[11\]\[23\]
+ _1426_ _1427_ VGND VGND VPWR VPWR _1654_ sky130_fd_sc_hd__mux4_1
X_5710_ _2881_ _2882_ VGND VGND VPWR VPWR _2883_ sky130_fd_sc_hd__and2_1
X_6690_ net757 _3393_ _3386_ _3396_ VGND VGND VPWR VPWR _0363_ sky130_fd_sc_hd__a31o_1
XFILLER_0_122_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_72_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5641_ net16 VGND VGND VPWR VPWR _2834_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_115_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5572_ net590 _2731_ _2789_ _2794_ VGND VGND VPWR VPWR _0840_ sky130_fd_sc_hd__a31o_1
X_7311_ clknet_leaf_107_clk _0870_ VGND VGND VPWR VPWR memory\[7\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_25_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4523_ _2180_ VGND VGND VPWR VPWR _0039_ sky130_fd_sc_hd__clkbuf_1
Xhold203 memory\[15\]\[24\] VGND VGND VPWR VPWR net412 sky130_fd_sc_hd__dlygate4sd3_1
X_7242_ clknet_leaf_34_clk _0833_ VGND VGND VPWR VPWR memory\[31\]\[27\] sky130_fd_sc_hd__dfxtp_1
Xhold214 memory\[12\]\[9\] VGND VGND VPWR VPWR net423 sky130_fd_sc_hd__dlygate4sd3_1
Xhold225 memory\[16\]\[3\] VGND VGND VPWR VPWR net434 sky130_fd_sc_hd__dlygate4sd3_1
Xhold247 memory\[30\]\[24\] VGND VGND VPWR VPWR net456 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_111_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold269 memory\[3\]\[21\] VGND VGND VPWR VPWR net478 sky130_fd_sc_hd__dlygate4sd3_1
Xhold258 memory\[2\]\[25\] VGND VGND VPWR VPWR net467 sky130_fd_sc_hd__dlygate4sd3_1
X_4454_ _2113_ _2114_ VGND VGND VPWR VPWR _2115_ sky130_fd_sc_hd__or2_1
Xhold236 memory\[31\]\[10\] VGND VGND VPWR VPWR net445 sky130_fd_sc_hd__dlygate4sd3_1
X_7173_ clknet_leaf_62_clk _0764_ VGND VGND VPWR VPWR memory\[2\]\[22\] sky130_fd_sc_hd__dfxtp_1
X_4385_ _2039_ _2049_ VGND VGND VPWR VPWR _2050_ sky130_fd_sc_hd__and2_1
X_6124_ _2863_ _3110_ VGND VGND VPWR VPWR _3113_ sky130_fd_sc_hd__and2_1
XTAP_530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6055_ net1033 _3062_ _3065_ _3072_ VGND VGND VPWR VPWR _1077_ sky130_fd_sc_hd__a31o_1
X_5006_ _2487_ _2504_ _2552_ VGND VGND VPWR VPWR _0548_ sky130_fd_sc_hd__a21o_1
XTAP_596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_109 _2171_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_1718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6957_ clknet_leaf_42_clk _0548_ VGND VGND VPWR VPWR memory\[10\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_72_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_552 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_72_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6888_ clknet_leaf_36_clk _0479_ VGND VGND VPWR VPWR memory\[28\]\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_76_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5908_ net780 _2981_ _2977_ _2987_ VGND VGND VPWR VPWR _1015_ sky130_fd_sc_hd__a31o_1
XFILLER_0_64_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5839_ net1175 _2943_ _2947_ VGND VGND VPWR VPWR _2948_ sky130_fd_sc_hd__and3_1
XFILLER_0_63_235 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_8_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_118_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_118_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7509_ clknet_leaf_11_clk _1068_ VGND VGND VPWR VPWR memory\[11\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_16_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_102_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold770 memory\[5\]\[0\] VGND VGND VPWR VPWR net979 sky130_fd_sc_hd__dlygate4sd3_1
Xhold781 memory\[24\]\[11\] VGND VGND VPWR VPWR net990 sky130_fd_sc_hd__dlygate4sd3_1
Xhold792 memory\[28\]\[13\] VGND VGND VPWR VPWR net1001 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_98_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_67_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_109_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_728 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_2_549 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4170_ memory\[4\]\[0\] memory\[5\]\[0\] memory\[6\]\[0\] memory\[7\]\[0\] _1842_
+ _1843_ VGND VGND VPWR VPWR _1844_ sky130_fd_sc_hd__mux4_1
X_7860_ clknet_leaf_6_clk _0394_ VGND VGND VPWR VPWR memory\[13\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_6811_ _2646_ _3441_ _3442_ net525 VGND VGND VPWR VPWR _0438_ sky130_fd_sc_hd__a22o_1
XFILLER_0_26_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7791_ clknet_leaf_23_clk _0325_ VGND VGND VPWR VPWR memory\[12\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_58_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3954_ _1483_ _1637_ VGND VGND VPWR VPWR _1638_ sky130_fd_sc_hd__or2_1
X_6742_ net39 _3387_ VGND VGND VPWR VPWR _3425_ sky130_fd_sc_hd__and2_1
XFILLER_0_9_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6673_ _3385_ VGND VGND VPWR VPWR _3386_ sky130_fd_sc_hd__buf_4
X_3885_ memory\[28\]\[19\] memory\[29\]\[19\] memory\[30\]\[19\] memory\[31\]\[19\]
+ _1398_ _1399_ VGND VGND VPWR VPWR _1572_ sky130_fd_sc_hd__mux4_1
XFILLER_0_115_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5624_ net330 _2811_ _2816_ _2823_ VGND VGND VPWR VPWR _0863_ sky130_fd_sc_hd__a31o_1
XFILLER_0_5_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5486_ _2774_ VGND VGND VPWR VPWR _2775_ sky130_fd_sc_hd__buf_4
XFILLER_0_77_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4506_ memory\[20\]\[16\] memory\[21\]\[16\] memory\[22\]\[16\] memory\[23\]\[16\]
+ _1938_ _1939_ VGND VGND VPWR VPWR _2164_ sky130_fd_sc_hd__mux4_1
XFILLER_0_14_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7225_ clknet_leaf_98_clk _0816_ VGND VGND VPWR VPWR memory\[31\]\[10\] sky130_fd_sc_hd__dfxtp_1
X_4437_ memory\[0\]\[12\] memory\[1\]\[12\] memory\[2\]\[12\] memory\[3\]\[12\] _2017_
+ _2018_ VGND VGND VPWR VPWR _2099_ sky130_fd_sc_hd__mux4_1
X_7156_ clknet_leaf_113_clk _0747_ VGND VGND VPWR VPWR memory\[2\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_4368_ _1815_ VGND VGND VPWR VPWR _2033_ sky130_fd_sc_hd__clkbuf_8
X_6107_ _2847_ _3097_ VGND VGND VPWR VPWR _3103_ sky130_fd_sc_hd__and2_1
XTAP_360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4299_ memory\[28\]\[6\] memory\[29\]\[6\] memory\[30\]\[6\] memory\[31\]\[6\] _1965_
+ _1966_ VGND VGND VPWR VPWR _1967_ sky130_fd_sc_hd__mux4_2
XTAP_393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7087_ clknet_leaf_7_clk _0678_ VGND VGND VPWR VPWR memory\[29\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_6038_ _2853_ _3053_ VGND VGND VPWR VPWR _3063_ sky130_fd_sc_hd__and2_1
XTAP_1515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_27_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3670_ _1245_ _1367_ VGND VGND VPWR VPWR _1368_ sky130_fd_sc_hd__or2_1
XFILLER_0_12_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_23_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_106_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5340_ _2468_ _2742_ _2743_ net585 VGND VGND VPWR VPWR _0691_ sky130_fd_sc_hd__a22o_1
Xoutput105 net105 VGND VGND VPWR VPWR data_out2[30] sky130_fd_sc_hd__clkbuf_4
X_5271_ net459 _2704_ _2707_ _2709_ VGND VGND VPWR VPWR _0656_ sky130_fd_sc_hd__a31o_1
X_7010_ clknet_leaf_100_clk _0601_ VGND VGND VPWR VPWR memory\[26\]\[19\] sky130_fd_sc_hd__dfxtp_1
X_4222_ _1892_ _1893_ _1869_ VGND VGND VPWR VPWR _1894_ sky130_fd_sc_hd__mux2_1
X_4153_ _1826_ VGND VGND VPWR VPWR _1827_ sky130_fd_sc_hd__clkbuf_4
X_4084_ _1752_ _1760_ VGND VGND VPWR VPWR _1761_ sky130_fd_sc_hd__and2_1
X_7912_ clknet_leaf_32_clk _0446_ VGND VGND VPWR VPWR memory\[17\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_77_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7843_ clknet_leaf_54_clk _0377_ VGND VGND VPWR VPWR memory\[9\]\[20\] sky130_fd_sc_hd__dfxtp_1
X_4986_ net1112 _2530_ _2540_ VGND VGND VPWR VPWR _2542_ sky130_fd_sc_hd__and3_1
XFILLER_0_93_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7774_ clknet_leaf_90_clk _0308_ VGND VGND VPWR VPWR memory\[30\]\[15\] sky130_fd_sc_hd__dfxtp_1
X_6725_ net406 _3406_ _3413_ _3416_ VGND VGND VPWR VPWR _0378_ sky130_fd_sc_hd__a31o_1
X_3937_ memory\[0\]\[21\] memory\[1\]\[21\] memory\[2\]\[21\] memory\[3\]\[21\] _1271_
+ _1272_ VGND VGND VPWR VPWR _1622_ sky130_fd_sc_hd__mux4_1
XFILLER_0_86_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_46_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_116_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_0__2784_ _2784_ VGND VGND VPWR VPWR clknet_0__2784_ sky130_fd_sc_hd__clkbuf_16
X_6656_ _2650_ _3380_ _3381_ net275 VGND VGND VPWR VPWR _0344_ sky130_fd_sc_hd__a22o_1
XFILLER_0_33_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3868_ _1397_ _1555_ _1401_ VGND VGND VPWR VPWR _1556_ sky130_fd_sc_hd__o21a_1
XFILLER_0_116_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5607_ _2648_ _2804_ VGND VGND VPWR VPWR _2814_ sky130_fd_sc_hd__and2_1
X_3799_ _1478_ _1490_ VGND VGND VPWR VPWR _1491_ sky130_fd_sc_hd__and2_1
X_6587_ _2905_ _3325_ VGND VGND VPWR VPWR _3365_ sky130_fd_sc_hd__and2_1
XFILLER_0_14_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5538_ clknet_1_0__leaf__2783_ VGND VGND VPWR VPWR _2785_ sky130_fd_sc_hd__buf_1
XFILLER_0_5_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7208_ clknet_leaf_54_clk _0799_ VGND VGND VPWR VPWR memory\[14\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_111_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5469_ _2473_ _2770_ _2771_ net520 VGND VGND VPWR VPWR _0792_ sky130_fd_sc_hd__a22o_1
XFILLER_0_1_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7139_ clknet_leaf_61_clk _0730_ VGND VGND VPWR VPWR memory\[3\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_69_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_96_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput18 data_in[11] VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_37_588 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xinput29 data_in[21] VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_107_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_122_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6839__47 clknet_1_1__leaf__3445_ VGND VGND VPWR VPWR net192 sky130_fd_sc_hd__inv_2
XFILLER_0_74_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_99_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_75_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4840_ net20 VGND VGND VPWR VPWR _2468_ sky130_fd_sc_hd__buf_4
XFILLER_0_28_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4771_ _2413_ _2414_ _2191_ VGND VGND VPWR VPWR _2415_ sky130_fd_sc_hd__mux2_1
X_6510_ net688 _3317_ _3279_ _3320_ VGND VGND VPWR VPWR _0259_ sky130_fd_sc_hd__a31o_1
XFILLER_0_83_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3722_ _1415_ _1416_ _1279_ VGND VGND VPWR VPWR _1417_ sky130_fd_sc_hd__mux2_1
X_7490_ clknet_leaf_99_clk _1049_ VGND VGND VPWR VPWR memory\[24\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_43_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f__3445_ clknet_0__3445_ VGND VGND VPWR VPWR clknet_1_0__leaf__3445_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_82_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3653_ memory\[16\]\[8\] memory\[17\]\[8\] memory\[18\]\[8\] memory\[19\]\[8\] _1349_
+ _1350_ VGND VGND VPWR VPWR _1351_ sky130_fd_sc_hd__mux4_1
X_6441_ _3281_ VGND VGND VPWR VPWR _3282_ sky130_fd_sc_hd__buf_2
X_6372_ _2842_ _3238_ VGND VGND VPWR VPWR _3242_ sky130_fd_sc_hd__and2_1
X_5323_ _2451_ _2738_ VGND VGND VPWR VPWR _2740_ sky130_fd_sc_hd__nor2_4
XFILLER_0_11_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_23_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3584_ memory\[4\]\[4\] memory\[5\]\[4\] memory\[6\]\[4\] memory\[7\]\[4\] _1237_
+ _1238_ VGND VGND VPWR VPWR _1286_ sky130_fd_sc_hd__mux4_1
X_5254_ net1062 _2675_ _2693_ _2699_ VGND VGND VPWR VPWR _0649_ sky130_fd_sc_hd__a31o_1
X_5185_ net891 _2652_ _2653_ _2670_ VGND VGND VPWR VPWR _0609_ sky130_fd_sc_hd__a31o_1
X_4205_ _1832_ VGND VGND VPWR VPWR _1878_ sky130_fd_sc_hd__buf_4
X_4136_ _1803_ _1806_ _1809_ VGND VGND VPWR VPWR _1810_ sky130_fd_sc_hd__mux2_1
X_4067_ _1744_ VGND VGND VPWR VPWR _0020_ sky130_fd_sc_hd__buf_1
XFILLER_0_64_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7826_ clknet_leaf_20_clk _0360_ VGND VGND VPWR VPWR memory\[9\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_108_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7757_ clknet_leaf_21_clk _0291_ VGND VGND VPWR VPWR memory\[22\]\[30\] sky130_fd_sc_hd__dfxtp_1
X_4969_ _2468_ _2525_ _2532_ VGND VGND VPWR VPWR _0531_ sky130_fd_sc_hd__a21o_1
X_7688_ clknet_leaf_28_clk _0222_ VGND VGND VPWR VPWR memory\[21\]\[25\] sky130_fd_sc_hd__dfxtp_1
X_6708_ net21 _3401_ VGND VGND VPWR VPWR _3407_ sky130_fd_sc_hd__and2_1
XFILLER_0_46_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6639_ _2617_ _3377_ _3379_ net524 VGND VGND VPWR VPWR _0329_ sky130_fd_sc_hd__a22o_1
XFILLER_0_14_260 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_14_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_100_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_411 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_69_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_639 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_80_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_110_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_904 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_915 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_926 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_948 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_937 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_959 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6990_ clknet_leaf_75_clk _0581_ VGND VGND VPWR VPWR memory\[6\]\[31\] sky130_fd_sc_hd__dfxtp_1
Xclkbuf_4_1_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_1_0_clk sky130_fd_sc_hd__clkbuf_8
X_5941_ _3005_ VGND VGND VPWR VPWR _3006_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_87_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5872_ net802 _2890_ _2963_ _2967_ VGND VGND VPWR VPWR _0999_ sky130_fd_sc_hd__a31o_1
XFILLER_0_8_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7611_ clknet_leaf_96_clk _0145_ VGND VGND VPWR VPWR memory\[27\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_28_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4823_ _2458_ _2449_ _2453_ net349 VGND VGND VPWR VPWR _0458_ sky130_fd_sc_hd__a22o_1
X_4754_ memory\[8\]\[29\] memory\[9\]\[29\] memory\[10\]\[29\] memory\[11\]\[29\]
+ _1837_ _1838_ VGND VGND VPWR VPWR _2399_ sky130_fd_sc_hd__mux4_1
XFILLER_0_56_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7542_ clknet_leaf_109_clk _1101_ VGND VGND VPWR VPWR memory\[20\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_83_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7473_ clknet_leaf_2_clk _1032_ VGND VGND VPWR VPWR memory\[24\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_3705_ _1153_ VGND VGND VPWR VPWR _1401_ sky130_fd_sc_hd__clkbuf_4
X_4685_ _2332_ _2333_ _1809_ VGND VGND VPWR VPWR _2334_ sky130_fd_sc_hd__mux2_1
XFILLER_0_70_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6424_ _2895_ _3264_ VGND VGND VPWR VPWR _3271_ sky130_fd_sc_hd__and2_1
X_3636_ _1169_ _1334_ VGND VGND VPWR VPWR _1335_ sky130_fd_sc_hd__or2_1
XFILLER_0_113_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6355_ _2669_ _3231_ _3232_ net859 VGND VGND VPWR VPWR _0192_ sky130_fd_sc_hd__a22o_1
XFILLER_0_101_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3567_ memory\[4\]\[3\] memory\[5\]\[3\] memory\[6\]\[3\] memory\[7\]\[3\] _1199_
+ _1200_ VGND VGND VPWR VPWR _1270_ sky130_fd_sc_hd__mux4_1
XFILLER_0_101_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5306_ net564 _2717_ _2720_ _2728_ VGND VGND VPWR VPWR _0672_ sky130_fd_sc_hd__a31o_1
XFILLER_0_59_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6286_ _2874_ _3197_ VGND VGND VPWR VPWR _3206_ sky130_fd_sc_hd__and2_1
X_5237_ _2485_ _2688_ _2689_ net978 VGND VGND VPWR VPWR _0642_ sky130_fd_sc_hd__a22o_1
X_3498_ memory\[0\]\[0\] memory\[1\]\[0\] memory\[2\]\[0\] memory\[3\]\[0\] _1202_
+ _1203_ VGND VGND VPWR VPWR _1204_ sky130_fd_sc_hd__mux4_1
X_5168_ net30 VGND VGND VPWR VPWR _2659_ sky130_fd_sc_hd__buf_4
X_4119_ _1207_ _1789_ _1791_ _1793_ net10 VGND VGND VPWR VPWR _1794_ sky130_fd_sc_hd__a221o_1
X_5099_ net27 VGND VGND VPWR VPWR _2611_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_94_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_109_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_109_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7809_ clknet_leaf_65_clk _0343_ VGND VGND VPWR VPWR memory\[12\]\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_93_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_61_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_120_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_104_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold7 memory\[13\]\[17\] VGND VGND VPWR VPWR net216 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_69_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_594 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_38_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_683 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_4_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold407 memory\[11\]\[25\] VGND VGND VPWR VPWR net616 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_25_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4470_ memory\[24\]\[14\] memory\[25\]\[14\] memory\[26\]\[14\] memory\[27\]\[14\]
+ _1872_ _1873_ VGND VGND VPWR VPWR _2130_ sky130_fd_sc_hd__mux4_1
Xhold418 memory\[3\]\[2\] VGND VGND VPWR VPWR net627 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_110_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold429 memory\[17\]\[14\] VGND VGND VPWR VPWR net638 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_369 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6140_ net450 _3117_ _3109_ _3121_ VGND VGND VPWR VPWR _1113_ sky130_fd_sc_hd__a31o_1
XTAP_701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6071_ _2886_ _3079_ VGND VGND VPWR VPWR _3082_ sky130_fd_sc_hd__and2_1
XTAP_745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_767 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5022_ net1136 _2557_ _2560_ VGND VGND VPWR VPWR _2564_ sky130_fd_sc_hd__and3_1
XTAP_789 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_778 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6973_ clknet_leaf_83_clk _0564_ VGND VGND VPWR VPWR memory\[6\]\[14\] sky130_fd_sc_hd__dfxtp_1
X_5924_ _2891_ _2991_ VGND VGND VPWR VPWR _2997_ sky130_fd_sc_hd__and2_1
XFILLER_0_76_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_75_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5855_ net1161 _2600_ _2947_ VGND VGND VPWR VPWR _2956_ sky130_fd_sc_hd__and3_1
XFILLER_0_0_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4806_ _2447_ VGND VGND VPWR VPWR _2448_ sky130_fd_sc_hd__buf_4
XFILLER_0_75_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5786_ _2676_ _2909_ _2911_ net325 VGND VGND VPWR VPWR _0932_ sky130_fd_sc_hd__a22o_1
X_7525_ clknet_leaf_56_clk _1084_ VGND VGND VPWR VPWR memory\[11\]\[22\] sky130_fd_sc_hd__dfxtp_1
X_4737_ memory\[4\]\[28\] memory\[5\]\[28\] memory\[6\]\[28\] memory\[7\]\[28\] _1804_
+ _1805_ VGND VGND VPWR VPWR _2383_ sky130_fd_sc_hd__mux4_1
XFILLER_0_9_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_44_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4668_ _2097_ _2313_ _2315_ _2317_ _2249_ VGND VGND VPWR VPWR _2318_ sky130_fd_sc_hd__a221o_1
XFILLER_0_71_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7456_ clknet_leaf_67_clk _1015_ VGND VGND VPWR VPWR memory\[1\]\[17\] sky130_fd_sc_hd__dfxtp_1
Xhold930 memory\[10\]\[20\] VGND VGND VPWR VPWR net1139 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_102_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_202 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6407_ _2878_ _3251_ VGND VGND VPWR VPWR _3261_ sky130_fd_sc_hd__and2_1
X_3619_ memory\[28\]\[6\] memory\[29\]\[6\] memory\[30\]\[6\] memory\[31\]\[6\] _1178_
+ _1179_ VGND VGND VPWR VPWR _1319_ sky130_fd_sc_hd__mux4_1
Xhold952 memory\[25\]\[28\] VGND VGND VPWR VPWR net1161 sky130_fd_sc_hd__dlygate4sd3_1
X_4599_ memory\[20\]\[21\] memory\[21\]\[21\] memory\[22\]\[21\] memory\[23\]\[21\]
+ _1938_ _1939_ VGND VGND VPWR VPWR _2252_ sky130_fd_sc_hd__mux4_1
Xhold941 memory\[10\]\[17\] VGND VGND VPWR VPWR net1150 sky130_fd_sc_hd__dlygate4sd3_1
X_7387_ clknet_leaf_87_clk _0946_ VGND VGND VPWR VPWR memory\[25\]\[12\] sky130_fd_sc_hd__dfxtp_1
Xhold963 memory\[25\]\[2\] VGND VGND VPWR VPWR net1172 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_101_268 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6338_ _2636_ _3229_ _3230_ net669 VGND VGND VPWR VPWR _0177_ sky130_fd_sc_hd__a22o_1
X_6269_ _3181_ VGND VGND VPWR VPWR _3196_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_86_509 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_79_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_94_520 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_27_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_325 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_35_686 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_105_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_120_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3970_ _1651_ _1652_ _1521_ VGND VGND VPWR VPWR _1653_ sky130_fd_sc_hd__mux2_1
XFILLER_0_15_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5640_ _2832_ VGND VGND VPWR VPWR _2833_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_122_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_664 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5571_ _2613_ _2791_ VGND VGND VPWR VPWR _2794_ sky130_fd_sc_hd__and2_1
X_7310_ clknet_leaf_41_clk _0869_ VGND VGND VPWR VPWR memory\[8\]\[31\] sky130_fd_sc_hd__dfxtp_1
X_5544__20 clknet_1_0__leaf__2785_ VGND VGND VPWR VPWR net165 sky130_fd_sc_hd__inv_2
XFILLER_0_5_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4522_ _2171_ _2179_ VGND VGND VPWR VPWR _2180_ sky130_fd_sc_hd__and2_1
X_7241_ clknet_leaf_35_clk _0832_ VGND VGND VPWR VPWR memory\[31\]\[26\] sky130_fd_sc_hd__dfxtp_1
Xhold204 memory\[16\]\[25\] VGND VGND VPWR VPWR net413 sky130_fd_sc_hd__dlygate4sd3_1
X_4453_ memory\[24\]\[13\] memory\[25\]\[13\] memory\[26\]\[13\] memory\[27\]\[13\]
+ _2032_ _2033_ VGND VGND VPWR VPWR _2114_ sky130_fd_sc_hd__mux4_1
Xhold215 memory\[16\]\[17\] VGND VGND VPWR VPWR net424 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_25_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold226 memory\[28\]\[7\] VGND VGND VPWR VPWR net435 sky130_fd_sc_hd__dlygate4sd3_1
Xhold259 memory\[18\]\[20\] VGND VGND VPWR VPWR net468 sky130_fd_sc_hd__dlygate4sd3_1
Xhold248 memory\[15\]\[13\] VGND VGND VPWR VPWR net457 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_41_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold237 memory\[31\]\[8\] VGND VGND VPWR VPWR net446 sky130_fd_sc_hd__dlygate4sd3_1
X_7172_ clknet_leaf_61_clk _0763_ VGND VGND VPWR VPWR memory\[2\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_0_263 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4384_ _1862_ _2042_ _2044_ _2048_ _1851_ VGND VGND VPWR VPWR _2049_ sky130_fd_sc_hd__a221o_1
X_6123_ net954 _3104_ _3109_ _3112_ VGND VGND VPWR VPWR _1105_ sky130_fd_sc_hd__a31o_1
XTAP_520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6054_ _2870_ _3066_ VGND VGND VPWR VPWR _3072_ sky130_fd_sc_hd__and2_1
X_5005_ net1115 _2543_ _2512_ VGND VGND VPWR VPWR _2552_ sky130_fd_sc_hd__and3_1
XTAP_586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6956_ clknet_leaf_37_clk _0547_ VGND VGND VPWR VPWR memory\[10\]\[29\] sky130_fd_sc_hd__dfxtp_1
XTAP_1719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5907_ _2874_ _2978_ VGND VGND VPWR VPWR _2987_ sky130_fd_sc_hd__and2_1
XFILLER_0_119_633 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6887_ clknet_leaf_37_clk _0478_ VGND VGND VPWR VPWR memory\[28\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_76_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_106_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5838_ _2920_ VGND VGND VPWR VPWR _2947_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_63_247 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_63_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5769_ _2642_ _2913_ _2914_ net801 VGND VGND VPWR VPWR _0917_ sky130_fd_sc_hd__a22o_1
XFILLER_0_17_642 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_7508_ clknet_leaf_11_clk _1067_ VGND VGND VPWR VPWR memory\[11\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_32_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_102_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7439_ clknet_leaf_102_clk _0998_ VGND VGND VPWR VPWR memory\[1\]\[0\] sky130_fd_sc_hd__dfxtp_1
Xhold760 memory\[7\]\[27\] VGND VGND VPWR VPWR net969 sky130_fd_sc_hd__dlygate4sd3_1
Xhold771 memory\[5\]\[15\] VGND VGND VPWR VPWR net980 sky130_fd_sc_hd__dlygate4sd3_1
Xhold782 memory\[4\]\[1\] VGND VGND VPWR VPWR net991 sky130_fd_sc_hd__dlygate4sd3_1
Xhold793 memory\[26\]\[0\] VGND VGND VPWR VPWR net1002 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_99_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_109_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_236 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_105_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_77_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_10_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_120_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_117_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6810_ _2644_ _3441_ _3442_ net417 VGND VGND VPWR VPWR _0437_ sky130_fd_sc_hd__a22o_1
X_7790_ clknet_leaf_21_clk _0324_ VGND VGND VPWR VPWR memory\[30\]\[31\] sky130_fd_sc_hd__dfxtp_1
X_6741_ net505 _2509_ _3413_ _3424_ VGND VGND VPWR VPWR _0386_ sky130_fd_sc_hd__a31o_1
X_3953_ memory\[8\]\[22\] memory\[9\]\[22\] memory\[10\]\[22\] memory\[11\]\[22\]
+ _1426_ _1427_ VGND VGND VPWR VPWR _1637_ sky130_fd_sc_hd__mux4_1
XFILLER_0_92_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6672_ _3384_ VGND VGND VPWR VPWR _3385_ sky130_fd_sc_hd__buf_2
X_3884_ _1394_ _1570_ VGND VGND VPWR VPWR _1571_ sky130_fd_sc_hd__or2_1
XFILLER_0_115_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5623_ _2665_ _2817_ VGND VGND VPWR VPWR _2823_ sky130_fd_sc_hd__and2_1
XFILLER_0_73_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5485_ _2489_ _2446_ _2490_ VGND VGND VPWR VPWR _2774_ sky130_fd_sc_hd__and3_1
X_4505_ _2163_ VGND VGND VPWR VPWR _0038_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_6_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_1_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4436_ memory\[4\]\[12\] memory\[5\]\[12\] memory\[6\]\[12\] memory\[7\]\[12\] _2014_
+ _2015_ VGND VGND VPWR VPWR _2098_ sky130_fd_sc_hd__mux4_1
X_7224_ clknet_leaf_3_clk _0815_ VGND VGND VPWR VPWR memory\[31\]\[9\] sky130_fd_sc_hd__dfxtp_1
X_4367_ _1813_ VGND VGND VPWR VPWR _2032_ sky130_fd_sc_hd__buf_8
X_7155_ clknet_leaf_104_clk _0746_ VGND VGND VPWR VPWR memory\[2\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_67_82 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_6_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6106_ net796 _3088_ _3095_ _3102_ VGND VGND VPWR VPWR _1098_ sky130_fd_sc_hd__a31o_1
X_7086_ clknet_leaf_45_clk _0677_ VGND VGND VPWR VPWR memory\[4\]\[31\] sky130_fd_sc_hd__dfxtp_1
X_4298_ _1832_ VGND VGND VPWR VPWR _1966_ sky130_fd_sc_hd__buf_6
XTAP_394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6037_ _3005_ VGND VGND VPWR VPWR _3062_ sky130_fd_sc_hd__buf_4
XFILLER_0_96_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6939_ clknet_leaf_70_clk _0530_ VGND VGND VPWR VPWR memory\[10\]\[12\] sky130_fd_sc_hd__dfxtp_1
XPHY_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_107_636 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_107_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_91_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_122_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_121_138 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_32_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_102_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold590 memory\[12\]\[0\] VGND VGND VPWR VPWR net799 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_87_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_55_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_103_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_103_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_103_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_12_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_70_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput106 net106 VGND VGND VPWR VPWR data_out2[31] sky130_fd_sc_hd__buf_2
X_5270_ _2631_ _2708_ VGND VGND VPWR VPWR _2709_ sky130_fd_sc_hd__and2_1
XFILLER_0_56_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4221_ memory\[0\]\[2\] memory\[1\]\[2\] memory\[2\]\[2\] memory\[3\]\[2\] _1866_
+ _1867_ VGND VGND VPWR VPWR _1893_ sky130_fd_sc_hd__mux4_1
X_4152_ net5 VGND VGND VPWR VPWR _1826_ sky130_fd_sc_hd__inv_2
X_4083_ _1207_ _1755_ _1757_ _1759_ _1606_ VGND VGND VPWR VPWR _1760_ sky130_fd_sc_hd__a221o_1
X_7911_ clknet_leaf_31_clk _0445_ VGND VGND VPWR VPWR memory\[17\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_78_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7842_ clknet_leaf_47_clk _0376_ VGND VGND VPWR VPWR memory\[9\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_53_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4985_ _2475_ _2539_ _2541_ VGND VGND VPWR VPWR _0538_ sky130_fd_sc_hd__a21o_1
XFILLER_0_58_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7773_ clknet_leaf_77_clk _0307_ VGND VGND VPWR VPWR memory\[30\]\[14\] sky130_fd_sc_hd__dfxtp_1
X_6724_ net29 _3414_ VGND VGND VPWR VPWR _3416_ sky130_fd_sc_hd__and2_1
X_3936_ memory\[4\]\[21\] memory\[5\]\[21\] memory\[6\]\[21\] memory\[7\]\[21\] _1199_
+ _1200_ VGND VGND VPWR VPWR _1621_ sky130_fd_sc_hd__mux4_1
Xclkbuf_0__2783_ _2783_ VGND VGND VPWR VPWR clknet_0__2783_ sky130_fd_sc_hd__clkbuf_16
X_6655_ _2648_ _3380_ _3381_ net712 VGND VGND VPWR VPWR _0343_ sky130_fd_sc_hd__a22o_1
XFILLER_0_73_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3867_ memory\[28\]\[18\] memory\[29\]\[18\] memory\[30\]\[18\] memory\[31\]\[18\]
+ _1398_ _1399_ VGND VGND VPWR VPWR _1555_ sky130_fd_sc_hd__mux4_1
XFILLER_0_104_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5606_ net680 _2811_ _2803_ _2813_ VGND VGND VPWR VPWR _0855_ sky130_fd_sc_hd__a31o_1
X_6586_ net957 _3359_ _3323_ _3364_ VGND VGND VPWR VPWR _0291_ sky130_fd_sc_hd__a31o_1
X_3798_ _1479_ _1482_ _1485_ _1489_ _1412_ VGND VGND VPWR VPWR _1490_ sky130_fd_sc_hd__a221o_1
XFILLER_0_61_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7207_ clknet_leaf_52_clk _0798_ VGND VGND VPWR VPWR memory\[14\]\[24\] sky130_fd_sc_hd__dfxtp_1
X_5468_ _2472_ _2770_ _2771_ net371 VGND VGND VPWR VPWR _0791_ sky130_fd_sc_hd__a22o_1
X_5399_ _2485_ _2754_ _2755_ net840 VGND VGND VPWR VPWR _0738_ sky130_fd_sc_hd__a22o_1
X_4419_ memory\[12\]\[11\] memory\[13\]\[11\] memory\[14\]\[11\] memory\[15\]\[11\]
+ _2045_ _2046_ VGND VGND VPWR VPWR _2082_ sky130_fd_sc_hd__mux4_2
XFILLER_0_10_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_7138_ clknet_leaf_68_clk _0729_ VGND VGND VPWR VPWR memory\[3\]\[19\] sky130_fd_sc_hd__dfxtp_1
X_7069_ clknet_leaf_84_clk _0660_ VGND VGND VPWR VPWR memory\[4\]\[14\] sky130_fd_sc_hd__dfxtp_1
XTAP_1313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_707 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xinput19 data_in[12] VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_91_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_122_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_107_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4770_ memory\[0\]\[30\] memory\[1\]\[30\] memory\[2\]\[30\] memory\[3\]\[30\] _1863_
+ _1864_ VGND VGND VPWR VPWR _2414_ sky130_fd_sc_hd__mux4_1
XFILLER_0_23_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_70_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3721_ memory\[16\]\[11\] memory\[17\]\[11\] memory\[18\]\[11\] memory\[19\]\[11\]
+ _1349_ _1350_ VGND VGND VPWR VPWR _1416_ sky130_fd_sc_hd__mux4_1
XFILLER_0_28_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6440_ _2690_ _2558_ _2736_ VGND VGND VPWR VPWR _3281_ sky130_fd_sc_hd__and3_4
X_3652_ _1158_ VGND VGND VPWR VPWR _1350_ sky130_fd_sc_hd__buf_4
XFILLER_0_43_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6371_ net722 _3233_ _3236_ _3241_ VGND VGND VPWR VPWR _0199_ sky130_fd_sc_hd__a31o_1
X_3583_ _1155_ _1280_ _1282_ _1284_ _1184_ VGND VGND VPWR VPWR _1285_ sky130_fd_sc_hd__a221o_1
X_5322_ _2738_ VGND VGND VPWR VPWR _2739_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_11_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5253_ _2615_ _2695_ VGND VGND VPWR VPWR _2699_ sky130_fd_sc_hd__and2_1
X_5184_ _2669_ _2655_ VGND VGND VPWR VPWR _2670_ sky130_fd_sc_hd__and2_1
X_4204_ _1830_ VGND VGND VPWR VPWR _1877_ sky130_fd_sc_hd__buf_6
X_4135_ _1808_ VGND VGND VPWR VPWR _1809_ sky130_fd_sc_hd__buf_8
X_4066_ _1735_ _1743_ VGND VGND VPWR VPWR _1744_ sky130_fd_sc_hd__and2_1
XFILLER_0_78_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_7825_ clknet_leaf_8_clk _0359_ VGND VGND VPWR VPWR memory\[9\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_109_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_7756_ clknet_leaf_24_clk _0290_ VGND VGND VPWR VPWR memory\[22\]\[29\] sky130_fd_sc_hd__dfxtp_1
X_4968_ memory\[10\]\[13\] _2530_ _2526_ VGND VGND VPWR VPWR _2532_ sky130_fd_sc_hd__and3_1
X_3919_ _1486_ _1604_ _1488_ VGND VGND VPWR VPWR _1605_ sky130_fd_sc_hd__o21a_1
X_7687_ clknet_leaf_27_clk _0221_ VGND VGND VPWR VPWR memory\[21\]\[24\] sky130_fd_sc_hd__dfxtp_1
X_4899_ _2495_ VGND VGND VPWR VPWR _2498_ sky130_fd_sc_hd__clkbuf_4
X_6707_ _2508_ VGND VGND VPWR VPWR _3406_ sky130_fd_sc_hd__buf_4
X_6638_ _2615_ _3377_ _3379_ net832 VGND VGND VPWR VPWR _0328_ sky130_fd_sc_hd__a22o_1
X_6569_ net1093 _3346_ _3351_ _3355_ VGND VGND VPWR VPWR _0283_ sky130_fd_sc_hd__a31o_1
XFILLER_0_69_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_96_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_128 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_65_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_632 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_4_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_122_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_122_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_905 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_916 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_927 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_949 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_938 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5940_ _2507_ VGND VGND VPWR VPWR _3005_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_19_9 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_7610_ clknet_leaf_96_clk _0144_ VGND VGND VPWR VPWR memory\[27\]\[11\] sky130_fd_sc_hd__dfxtp_1
X_5871_ _2838_ _2965_ VGND VGND VPWR VPWR _2967_ sky130_fd_sc_hd__and2_1
X_4822_ net43 VGND VGND VPWR VPWR _2458_ sky130_fd_sc_hd__buf_4
X_4753_ _2396_ _2397_ _2191_ VGND VGND VPWR VPWR _2398_ sky130_fd_sc_hd__mux2_1
XFILLER_0_7_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7541_ clknet_leaf_109_clk _1100_ VGND VGND VPWR VPWR memory\[20\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_114_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_71_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7472_ clknet_leaf_0_clk _1031_ VGND VGND VPWR VPWR memory\[24\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_3704_ memory\[28\]\[10\] memory\[29\]\[10\] memory\[30\]\[10\] memory\[31\]\[10\]
+ _1398_ _1399_ VGND VGND VPWR VPWR _1400_ sky130_fd_sc_hd__mux4_1
XFILLER_0_50_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6423_ net948 _3262_ _3263_ _3270_ VGND VGND VPWR VPWR _0222_ sky130_fd_sc_hd__a31o_1
X_4684_ memory\[0\]\[25\] memory\[1\]\[25\] memory\[2\]\[25\] memory\[3\]\[25\] _1845_
+ _1846_ VGND VGND VPWR VPWR _2333_ sky130_fd_sc_hd__mux4_1
XFILLER_0_71_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_70_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_70_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_70_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3635_ memory\[24\]\[7\] memory\[25\]\[7\] memory\[26\]\[7\] memory\[27\]\[7\] _1171_
+ _1173_ VGND VGND VPWR VPWR _1334_ sky130_fd_sc_hd__mux4_1
X_6354_ _2667_ _3231_ _3232_ net267 VGND VGND VPWR VPWR _0191_ sky130_fd_sc_hd__a22o_1
X_3566_ _1193_ _1268_ _1197_ VGND VGND VPWR VPWR _1269_ sky130_fd_sc_hd__o21a_1
X_5305_ _2667_ _2721_ VGND VGND VPWR VPWR _2728_ sky130_fd_sc_hd__and2_1
X_3497_ _1189_ VGND VGND VPWR VPWR _1203_ sky130_fd_sc_hd__clkbuf_8
X_6285_ net953 _3200_ _3196_ _3205_ VGND VGND VPWR VPWR _0149_ sky130_fd_sc_hd__a31o_1
X_5236_ _2484_ _2688_ _2689_ net297 VGND VGND VPWR VPWR _0641_ sky130_fd_sc_hd__a22o_1
X_5167_ net640 _2652_ _2653_ _2658_ VGND VGND VPWR VPWR _0603_ sky130_fd_sc_hd__a31o_1
X_4118_ _1193_ _1792_ _1197_ VGND VGND VPWR VPWR _1793_ sky130_fd_sc_hd__o21a_1
X_5098_ net1002 _2601_ _2606_ _2610_ VGND VGND VPWR VPWR _0582_ sky130_fd_sc_hd__a31o_1
X_4049_ _1727_ VGND VGND VPWR VPWR _0019_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_94_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_78_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7808_ clknet_leaf_65_clk _0342_ VGND VGND VPWR VPWR memory\[12\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_38_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7739_ clknet_leaf_94_clk _0273_ VGND VGND VPWR VPWR memory\[22\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_19_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold8 memory\[17\]\[10\] VGND VGND VPWR VPWR net217 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_97_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_57_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_72_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_65_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold408 memory\[13\]\[0\] VGND VGND VPWR VPWR net617 sky130_fd_sc_hd__dlygate4sd3_1
Xhold419 memory\[29\]\[29\] VGND VGND VPWR VPWR net628 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_96_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_0_434 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6070_ net846 _3075_ _3078_ _3081_ VGND VGND VPWR VPWR _1083_ sky130_fd_sc_hd__a31o_1
XTAP_735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_768 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5021_ _2455_ _2556_ _2563_ VGND VGND VPWR VPWR _0552_ sky130_fd_sc_hd__a21o_1
XTAP_779 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6972_ clknet_leaf_84_clk _0563_ VGND VGND VPWR VPWR memory\[6\]\[13\] sky130_fd_sc_hd__dfxtp_1
X_5923_ net824 _2994_ _2990_ _2996_ VGND VGND VPWR VPWR _1021_ sky130_fd_sc_hd__a31o_1
XFILLER_0_88_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5854_ _2484_ _2946_ _2955_ VGND VGND VPWR VPWR _0961_ sky130_fd_sc_hd__a21o_1
XFILLER_0_75_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4805_ _2440_ _2441_ _2442_ _2446_ VGND VGND VPWR VPWR _2447_ sky130_fd_sc_hd__and4_1
XFILLER_0_75_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7524_ clknet_leaf_53_clk _1083_ VGND VGND VPWR VPWR memory\[11\]\[21\] sky130_fd_sc_hd__dfxtp_1
X_5785_ _2673_ _2915_ _2916_ net598 VGND VGND VPWR VPWR _0931_ sky130_fd_sc_hd__a22o_1
XFILLER_0_8_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4736_ _1976_ _2381_ _1796_ VGND VGND VPWR VPWR _2382_ sky130_fd_sc_hd__o21a_1
X_4667_ _2104_ _2316_ _2106_ VGND VGND VPWR VPWR _2317_ sky130_fd_sc_hd__o21a_1
X_7455_ clknet_leaf_81_clk _1014_ VGND VGND VPWR VPWR memory\[1\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_44_687 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6406_ net1004 _3249_ _3250_ _3260_ VGND VGND VPWR VPWR _0215_ sky130_fd_sc_hd__a31o_1
Xhold920 memory\[6\]\[7\] VGND VGND VPWR VPWR net1129 sky130_fd_sc_hd__dlygate4sd3_1
Xhold931 memory\[25\]\[11\] VGND VGND VPWR VPWR net1140 sky130_fd_sc_hd__dlygate4sd3_1
X_7386_ clknet_leaf_96_clk _0945_ VGND VGND VPWR VPWR memory\[25\]\[11\] sky130_fd_sc_hd__dfxtp_1
X_3618_ _1169_ _1317_ VGND VGND VPWR VPWR _1318_ sky130_fd_sc_hd__or2_1
Xhold953 memory\[10\]\[23\] VGND VGND VPWR VPWR net1162 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_101_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold942 memory\[6\]\[22\] VGND VGND VPWR VPWR net1151 sky130_fd_sc_hd__dlygate4sd3_1
X_4598_ _2251_ VGND VGND VPWR VPWR _0044_ sky130_fd_sc_hd__buf_1
X_6337_ _2634_ _3229_ _3230_ net518 VGND VGND VPWR VPWR _0176_ sky130_fd_sc_hd__a22o_1
Xhold964 memory\[25\]\[4\] VGND VGND VPWR VPWR net1173 sky130_fd_sc_hd__dlygate4sd3_1
X_3549_ memory\[12\]\[2\] memory\[13\]\[2\] memory\[14\]\[2\] memory\[15\]\[2\] _1251_
+ _1252_ VGND VGND VPWR VPWR _1253_ sky130_fd_sc_hd__mux4_1
X_6268_ net731 _3187_ _3182_ _3195_ VGND VGND VPWR VPWR _0142_ sky130_fd_sc_hd__a31o_1
X_6199_ net860 _3146_ _3153_ _3156_ VGND VGND VPWR VPWR _1137_ sky130_fd_sc_hd__a31o_1
X_5219_ _2467_ _2686_ _2687_ net1034 VGND VGND VPWR VPWR _0626_ sky130_fd_sc_hd__a22o_1
XFILLER_0_109_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_4_0_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_0_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_34_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_280 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_57_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_122_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_57_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_115_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_110_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5570_ net539 _2731_ _2789_ _2793_ VGND VGND VPWR VPWR _0839_ sky130_fd_sc_hd__a31o_1
XFILLER_0_25_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4521_ _2173_ _2175_ _2178_ _1850_ _2066_ VGND VGND VPWR VPWR _2179_ sky130_fd_sc_hd__a221o_1
XFILLER_0_26_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7240_ clknet_leaf_36_clk _0831_ VGND VGND VPWR VPWR memory\[31\]\[25\] sky130_fd_sc_hd__dfxtp_1
X_4452_ _1811_ VGND VGND VPWR VPWR _2113_ sky130_fd_sc_hd__buf_4
Xhold205 memory\[23\]\[20\] VGND VGND VPWR VPWR net414 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold216 memory\[8\]\[10\] VGND VGND VPWR VPWR net425 sky130_fd_sc_hd__dlygate4sd3_1
Xhold227 memory\[13\]\[19\] VGND VGND VPWR VPWR net436 sky130_fd_sc_hd__dlygate4sd3_1
Xhold238 memory\[3\]\[0\] VGND VGND VPWR VPWR net447 sky130_fd_sc_hd__dlygate4sd3_1
Xhold249 memory\[1\]\[9\] VGND VGND VPWR VPWR net458 sky130_fd_sc_hd__dlygate4sd3_1
X_7171_ clknet_leaf_61_clk _0762_ VGND VGND VPWR VPWR memory\[2\]\[20\] sky130_fd_sc_hd__dfxtp_1
X_4383_ _1876_ _2047_ _1880_ VGND VGND VPWR VPWR _2048_ sky130_fd_sc_hd__o21a_1
X_6122_ _2861_ _3110_ VGND VGND VPWR VPWR _3112_ sky130_fd_sc_hd__and2_1
XFILLER_0_0_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6053_ net380 _3062_ _3065_ _3071_ VGND VGND VPWR VPWR _1076_ sky130_fd_sc_hd__a31o_1
X_5004_ _2486_ _2539_ _2551_ VGND VGND VPWR VPWR _0547_ sky130_fd_sc_hd__a21o_1
XFILLER_0_56_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6955_ clknet_leaf_38_clk _0546_ VGND VGND VPWR VPWR memory\[10\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_88_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5906_ net433 _2981_ _2977_ _2986_ VGND VGND VPWR VPWR _1014_ sky130_fd_sc_hd__a31o_1
X_6886_ clknet_leaf_37_clk _0477_ VGND VGND VPWR VPWR memory\[28\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_119_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_63_204 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_118_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5837_ _2918_ VGND VGND VPWR VPWR _2946_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_91_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5768_ _2640_ _2913_ _2914_ net519 VGND VGND VPWR VPWR _0916_ sky130_fd_sc_hd__a22o_1
XFILLER_0_17_654 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4719_ _1829_ _2365_ VGND VGND VPWR VPWR _2366_ sky130_fd_sc_hd__or2_1
X_7507_ clknet_leaf_9_clk _1066_ VGND VGND VPWR VPWR memory\[11\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_44_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_114_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7438_ clknet_leaf_43_clk net114 VGND VGND VPWR VPWR memory\[0\]\[31\] sky130_fd_sc_hd__dfxtp_1
X_5699_ _2874_ _2859_ VGND VGND VPWR VPWR _2875_ sky130_fd_sc_hd__and2_1
Xhold761 memory\[26\]\[25\] VGND VGND VPWR VPWR net970 sky130_fd_sc_hd__dlygate4sd3_1
X_7369_ clknet_leaf_31_clk _0928_ VGND VGND VPWR VPWR memory\[18\]\[26\] sky130_fd_sc_hd__dfxtp_1
Xhold772 memory\[23\]\[25\] VGND VGND VPWR VPWR net981 sky130_fd_sc_hd__dlygate4sd3_1
Xhold750 memory\[15\]\[9\] VGND VGND VPWR VPWR net959 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_102_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold794 memory\[18\]\[18\] VGND VGND VPWR VPWR net1003 sky130_fd_sc_hd__dlygate4sd3_1
Xhold783 memory\[26\]\[1\] VGND VGND VPWR VPWR net992 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_39_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_109_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_112_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_93_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_89_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6740_ net37 _3414_ VGND VGND VPWR VPWR _3424_ sky130_fd_sc_hd__and2_1
Xclkbuf_leaf_109_clk clknet_4_1_0_clk VGND VGND VPWR VPWR clknet_leaf_109_clk sky130_fd_sc_hd__clkbuf_16
X_3952_ _1634_ _1635_ _1521_ VGND VGND VPWR VPWR _1636_ sky130_fd_sc_hd__mux2_1
XFILLER_0_18_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6671_ _2503_ _2960_ VGND VGND VPWR VPWR _3384_ sky130_fd_sc_hd__or2_1
X_3883_ memory\[24\]\[19\] memory\[25\]\[19\] memory\[26\]\[19\] memory\[27\]\[19\]
+ _1551_ _1552_ VGND VGND VPWR VPWR _1570_ sky130_fd_sc_hd__mux4_1
XFILLER_0_116_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5622_ net346 _2811_ _2816_ _2822_ VGND VGND VPWR VPWR _0862_ sky130_fd_sc_hd__a31o_1
XFILLER_0_73_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4504_ _2154_ _2162_ VGND VGND VPWR VPWR _2163_ sky130_fd_sc_hd__and2_1
X_5484_ _2488_ _2766_ _2768_ net609 VGND VGND VPWR VPWR _0805_ sky130_fd_sc_hd__a22o_1
X_4435_ _1797_ VGND VGND VPWR VPWR _2097_ sky130_fd_sc_hd__buf_4
XFILLER_0_13_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_487 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_7223_ clknet_leaf_7_clk _0814_ VGND VGND VPWR VPWR memory\[31\]\[8\] sky130_fd_sc_hd__dfxtp_1
X_4366_ _2027_ _2030_ _1903_ VGND VGND VPWR VPWR _2031_ sky130_fd_sc_hd__mux2_1
XFILLER_0_6_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_7154_ clknet_leaf_104_clk _0745_ VGND VGND VPWR VPWR memory\[2\]\[3\] sky130_fd_sc_hd__dfxtp_1
XTAP_340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6105_ _2845_ _3097_ VGND VGND VPWR VPWR _3102_ sky130_fd_sc_hd__and2_1
X_4297_ _1830_ VGND VGND VPWR VPWR _1965_ sky130_fd_sc_hd__buf_8
X_7085_ clknet_leaf_45_clk _0676_ VGND VGND VPWR VPWR memory\[4\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_67_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6036_ net1098 _3047_ _3051_ _3061_ VGND VGND VPWR VPWR _1069_ sky130_fd_sc_hd__a31o_1
XFILLER_0_96_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6938_ clknet_leaf_75_clk _0529_ VGND VGND VPWR VPWR memory\[10\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_64_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6869_ clknet_leaf_5_clk _0460_ VGND VGND VPWR VPWR memory\[28\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_64_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_64_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_8_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_107_648 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_51_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_115_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold580 memory\[18\]\[4\] VGND VGND VPWR VPWR net789 sky130_fd_sc_hd__dlygate4sd3_1
Xhold591 memory\[21\]\[29\] VGND VGND VPWR VPWR net800 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_99_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_55_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput107 net107 VGND VGND VPWR VPWR data_out2[3] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_23_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_121_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4220_ memory\[4\]\[2\] memory\[5\]\[2\] memory\[6\]\[2\] memory\[7\]\[2\] _1863_
+ _1864_ VGND VGND VPWR VPWR _1892_ sky130_fd_sc_hd__mux4_1
X_4151_ _1820_ _1823_ _1824_ VGND VGND VPWR VPWR _1825_ sky130_fd_sc_hd__o21a_1
X_4082_ _1193_ _1758_ _1197_ VGND VGND VPWR VPWR _1759_ sky130_fd_sc_hd__o21a_1
X_7910_ clknet_leaf_39_clk _0444_ VGND VGND VPWR VPWR memory\[17\]\[23\] sky130_fd_sc_hd__dfxtp_1
X_7841_ clknet_leaf_76_clk _0375_ VGND VGND VPWR VPWR memory\[9\]\[18\] sky130_fd_sc_hd__dfxtp_1
X_4984_ net1139 _2530_ _2540_ VGND VGND VPWR VPWR _2541_ sky130_fd_sc_hd__and3_1
X_7772_ clknet_leaf_90_clk _0306_ VGND VGND VPWR VPWR memory\[30\]\[13\] sky130_fd_sc_hd__dfxtp_1
X_6723_ net529 _3406_ _3413_ _3415_ VGND VGND VPWR VPWR _0377_ sky130_fd_sc_hd__a31o_1
X_3935_ _1205_ _1619_ _1153_ VGND VGND VPWR VPWR _1620_ sky130_fd_sc_hd__o21a_1
XFILLER_0_19_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6654_ _2646_ _3380_ _3381_ net237 VGND VGND VPWR VPWR _0342_ sky130_fd_sc_hd__a22o_1
XFILLER_0_46_568 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5605_ _2646_ _2804_ VGND VGND VPWR VPWR _2813_ sky130_fd_sc_hd__and2_1
X_3866_ _1394_ _1553_ VGND VGND VPWR VPWR _1554_ sky130_fd_sc_hd__or2_1
XFILLER_0_116_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_103_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3797_ _1486_ _1487_ _1488_ VGND VGND VPWR VPWR _1489_ sky130_fd_sc_hd__o21a_1
X_6585_ _2903_ _3325_ VGND VGND VPWR VPWR _3364_ sky130_fd_sc_hd__and2_1
XFILLER_0_14_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5467_ _2471_ _2770_ _2771_ net452 VGND VGND VPWR VPWR _0790_ sky130_fd_sc_hd__a22o_1
X_7206_ clknet_leaf_57_clk _0797_ VGND VGND VPWR VPWR memory\[14\]\[23\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_78_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4418_ _1871_ _2080_ VGND VGND VPWR VPWR _2081_ sky130_fd_sc_hd__or2_1
X_5398_ _2484_ _2754_ _2755_ net279 VGND VGND VPWR VPWR _0737_ sky130_fd_sc_hd__a22o_1
X_4349_ net2 VGND VGND VPWR VPWR _2015_ sky130_fd_sc_hd__clkbuf_8
X_7137_ clknet_leaf_82_clk _0728_ VGND VGND VPWR VPWR memory\[3\]\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_10_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7068_ clknet_leaf_84_clk _0659_ VGND VGND VPWR VPWR memory\[4\]\[13\] sky130_fd_sc_hd__dfxtp_1
X_6019_ _2510_ _2490_ _2511_ VGND VGND VPWR VPWR _3052_ sky130_fd_sc_hd__and3_2
XTAP_1314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_340 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_107_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_107_434 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_25_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_103_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_102_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_74_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1870 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_114_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3720_ memory\[20\]\[11\] memory\[21\]\[11\] memory\[22\]\[11\] memory\[23\]\[11\]
+ _1312_ _1313_ VGND VGND VPWR VPWR _1415_ sky130_fd_sc_hd__mux4_1
Xclkbuf_leaf_40_clk clknet_4_9_0_clk VGND VGND VPWR VPWR clknet_leaf_40_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_55_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3651_ _1156_ VGND VGND VPWR VPWR _1349_ sky130_fd_sc_hd__buf_4
X_6370_ _2840_ _3238_ VGND VGND VPWR VPWR _3241_ sky130_fd_sc_hd__and2_1
X_3582_ _1177_ _1283_ _1181_ VGND VGND VPWR VPWR _1284_ sky130_fd_sc_hd__o21a_1
X_5321_ _2737_ VGND VGND VPWR VPWR _2738_ sky130_fd_sc_hd__buf_4
XFILLER_0_11_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5252_ net770 _2675_ _2693_ _2698_ VGND VGND VPWR VPWR _0648_ sky130_fd_sc_hd__a31o_1
X_5183_ net35 VGND VGND VPWR VPWR _2669_ sky130_fd_sc_hd__clkbuf_4
X_4203_ _1808_ VGND VGND VPWR VPWR _1876_ sky130_fd_sc_hd__buf_4
X_4134_ _1807_ VGND VGND VPWR VPWR _1808_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_48_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4065_ _1479_ _1738_ _1740_ _1742_ _1606_ VGND VGND VPWR VPWR _1743_ sky130_fd_sc_hd__a221o_1
X_7824_ clknet_leaf_15_clk _0358_ VGND VGND VPWR VPWR memory\[9\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_65_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7755_ clknet_leaf_24_clk _0289_ VGND VGND VPWR VPWR memory\[22\]\[28\] sky130_fd_sc_hd__dfxtp_1
X_4967_ _2467_ _2525_ _2531_ VGND VGND VPWR VPWR _0530_ sky130_fd_sc_hd__a21o_1
XFILLER_0_117_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_leaf_31_clk clknet_4_10_0_clk VGND VGND VPWR VPWR clknet_leaf_31_clk sky130_fd_sc_hd__clkbuf_16
X_3918_ memory\[12\]\[20\] memory\[13\]\[20\] memory\[14\]\[20\] memory\[15\]\[20\]
+ _1430_ _1431_ VGND VGND VPWR VPWR _1604_ sky130_fd_sc_hd__mux4_1
X_7686_ clknet_leaf_27_clk _0220_ VGND VGND VPWR VPWR memory\[21\]\[23\] sky130_fd_sc_hd__dfxtp_1
X_4898_ _2493_ VGND VGND VPWR VPWR _2497_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_73_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6706_ net465 _3393_ _3400_ _3405_ VGND VGND VPWR VPWR _0370_ sky130_fd_sc_hd__a31o_1
XFILLER_0_61_302 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_73_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3849_ memory\[0\]\[17\] memory\[1\]\[17\] memory\[2\]\[17\] memory\[3\]\[17\] _1363_
+ _1364_ VGND VGND VPWR VPWR _1538_ sky130_fd_sc_hd__mux4_1
X_6637_ _2613_ _3377_ _3379_ net395 VGND VGND VPWR VPWR _0327_ sky130_fd_sc_hd__a22o_1
XFILLER_0_6_462 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_6_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6568_ _2886_ _3352_ VGND VGND VPWR VPWR _3355_ sky130_fd_sc_hd__and2_1
XFILLER_0_61_357 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_14_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5519_ _2665_ _2781_ _2782_ net366 VGND VGND VPWR VPWR _0831_ sky130_fd_sc_hd__a22o_1
XFILLER_0_14_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6499_ net523 _3304_ _3307_ _3314_ VGND VGND VPWR VPWR _0254_ sky130_fd_sc_hd__a31o_1
XFILLER_0_100_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_leaf_98_clk clknet_4_6_0_clk VGND VGND VPWR VPWR clknet_leaf_98_clk sky130_fd_sc_hd__clkbuf_16
X_6844__52 clknet_1_1__leaf__3445_ VGND VGND VPWR VPWR net197 sky130_fd_sc_hd__inv_2
XFILLER_0_97_711 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_leaf_22_clk clknet_4_8_0_clk VGND VGND VPWR VPWR clknet_leaf_22_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_25_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_107_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_519 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_52_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_100_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_122_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_906 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_917 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_928 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_939 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_89_clk clknet_4_5_0_clk VGND VGND VPWR VPWR clknet_leaf_89_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_87_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5870_ net750 _2890_ _2963_ _2966_ VGND VGND VPWR VPWR _0998_ sky130_fd_sc_hd__a31o_1
X_4821_ _2457_ _2449_ _2453_ net634 VGND VGND VPWR VPWR _0457_ sky130_fd_sc_hd__a22o_1
XFILLER_0_75_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4752_ memory\[0\]\[29\] memory\[1\]\[29\] memory\[2\]\[29\] memory\[3\]\[29\] _1863_
+ _1864_ VGND VGND VPWR VPWR _2397_ sky130_fd_sc_hd__mux4_1
Xclkbuf_leaf_13_clk clknet_4_3_0_clk VGND VGND VPWR VPWR clknet_leaf_13_clk sky130_fd_sc_hd__clkbuf_16
X_7540_ clknet_leaf_111_clk _1099_ VGND VGND VPWR VPWR memory\[20\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_4683_ memory\[4\]\[25\] memory\[5\]\[25\] memory\[6\]\[25\] memory\[7\]\[25\] _1804_
+ _1805_ VGND VGND VPWR VPWR _2332_ sky130_fd_sc_hd__mux4_1
X_3703_ _1172_ VGND VGND VPWR VPWR _1399_ sky130_fd_sc_hd__clkbuf_4
X_7471_ clknet_leaf_4_clk _1030_ VGND VGND VPWR VPWR memory\[24\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_114_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6422_ _2893_ _3264_ VGND VGND VPWR VPWR _3270_ sky130_fd_sc_hd__and2_1
X_3634_ _1331_ _1332_ _1279_ VGND VGND VPWR VPWR _1333_ sky130_fd_sc_hd__mux2_1
XFILLER_0_113_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6353_ _2665_ _3231_ _3232_ net495 VGND VGND VPWR VPWR _0190_ sky130_fd_sc_hd__a22o_1
X_3565_ memory\[12\]\[3\] memory\[13\]\[3\] memory\[14\]\[3\] memory\[15\]\[3\] _1194_
+ _1195_ VGND VGND VPWR VPWR _1268_ sky130_fd_sc_hd__mux4_2
X_5304_ net1063 _2717_ _2720_ _2727_ VGND VGND VPWR VPWR _0671_ sky130_fd_sc_hd__a31o_1
X_3496_ _1187_ VGND VGND VPWR VPWR _1202_ sky130_fd_sc_hd__clkbuf_8
X_6284_ _2872_ _3197_ VGND VGND VPWR VPWR _3205_ sky130_fd_sc_hd__and2_1
X_5235_ _2483_ _2688_ _2689_ net258 VGND VGND VPWR VPWR _0640_ sky130_fd_sc_hd__a22o_1
XFILLER_0_45_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5166_ _2657_ _2655_ VGND VGND VPWR VPWR _2658_ sky130_fd_sc_hd__and2_1
XFILLER_0_98_519 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4117_ memory\[12\]\[31\] memory\[13\]\[31\] memory\[14\]\[31\] memory\[15\]\[31\]
+ _1246_ _1247_ VGND VGND VPWR VPWR _1792_ sky130_fd_sc_hd__mux4_1
X_5097_ _2607_ _2609_ VGND VGND VPWR VPWR _2610_ sky130_fd_sc_hd__and2_1
X_4048_ _1718_ _1726_ VGND VGND VPWR VPWR _1727_ sky130_fd_sc_hd__and2_1
XPHY_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5999_ net821 _3034_ _3035_ _3040_ VGND VGND VPWR VPWR _1053_ sky130_fd_sc_hd__a31o_1
X_7807_ clknet_leaf_67_clk _0341_ VGND VGND VPWR VPWR memory\[12\]\[16\] sky130_fd_sc_hd__dfxtp_1
X_7738_ clknet_leaf_109_clk _0272_ VGND VGND VPWR VPWR memory\[22\]\[11\] sky130_fd_sc_hd__dfxtp_1
X_7669_ clknet_leaf_110_clk _0203_ VGND VGND VPWR VPWR memory\[21\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_6_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold9 memory\[14\]\[15\] VGND VGND VPWR VPWR net218 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_57_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold409 memory\[12\]\[1\] VGND VGND VPWR VPWR net618 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_111_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5020_ net1171 _2557_ _2560_ VGND VGND VPWR VPWR _2563_ sky130_fd_sc_hd__and3_1
XTAP_736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_2_clk clknet_4_2_0_clk VGND VGND VPWR VPWR clknet_leaf_2_clk sky130_fd_sc_hd__clkbuf_16
XTAP_769 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6971_ clknet_leaf_84_clk _0562_ VGND VGND VPWR VPWR memory\[6\]\[12\] sky130_fd_sc_hd__dfxtp_1
X_5922_ _2888_ _2991_ VGND VGND VPWR VPWR _2996_ sky130_fd_sc_hd__and2_1
XFILLER_0_0_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5853_ net1155 _2943_ _2947_ VGND VGND VPWR VPWR _2955_ sky130_fd_sc_hd__and3_1
XFILLER_0_0_44 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5784_ _2671_ _2915_ _2916_ net255 VGND VGND VPWR VPWR _0930_ sky130_fd_sc_hd__a22o_1
X_4804_ _2443_ _2444_ _2445_ VGND VGND VPWR VPWR _2446_ sky130_fd_sc_hd__and3_1
X_4735_ memory\[12\]\[28\] memory\[13\]\[28\] memory\[14\]\[28\] memory\[15\]\[28\]
+ _1973_ _1974_ VGND VGND VPWR VPWR _2381_ sky130_fd_sc_hd__mux4_1
X_7523_ clknet_leaf_54_clk _1082_ VGND VGND VPWR VPWR memory\[11\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_83_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4666_ memory\[12\]\[24\] memory\[13\]\[24\] memory\[14\]\[24\] memory\[15\]\[24\]
+ _1965_ _1966_ VGND VGND VPWR VPWR _2316_ sky130_fd_sc_hd__mux4_1
XFILLER_0_44_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7454_ clknet_leaf_83_clk _1013_ VGND VGND VPWR VPWR memory\[1\]\[15\] sky130_fd_sc_hd__dfxtp_1
X_4597_ _2241_ _2250_ VGND VGND VPWR VPWR _2251_ sky130_fd_sc_hd__and2_1
Xhold921 memory\[10\]\[1\] VGND VGND VPWR VPWR net1130 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_9_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7385_ clknet_leaf_97_clk _0944_ VGND VGND VPWR VPWR memory\[25\]\[10\] sky130_fd_sc_hd__dfxtp_1
X_6405_ _2876_ _3251_ VGND VGND VPWR VPWR _3260_ sky130_fd_sc_hd__and2_1
Xhold910 memory\[25\]\[7\] VGND VGND VPWR VPWR net1119 sky130_fd_sc_hd__dlygate4sd3_1
X_3617_ memory\[24\]\[6\] memory\[25\]\[6\] memory\[26\]\[6\] memory\[27\]\[6\] _1171_
+ _1173_ VGND VGND VPWR VPWR _1317_ sky130_fd_sc_hd__mux4_1
XFILLER_0_43_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold954 memory\[10\]\[28\] VGND VGND VPWR VPWR net1163 sky130_fd_sc_hd__dlygate4sd3_1
X_3548_ _1189_ VGND VGND VPWR VPWR _1252_ sky130_fd_sc_hd__buf_4
X_6336_ _2631_ _3229_ _3230_ net305 VGND VGND VPWR VPWR _0175_ sky130_fd_sc_hd__a22o_1
Xhold943 memory\[6\]\[5\] VGND VGND VPWR VPWR net1152 sky130_fd_sc_hd__dlygate4sd3_1
Xhold932 memory\[6\]\[15\] VGND VGND VPWR VPWR net1141 sky130_fd_sc_hd__dlygate4sd3_1
Xhold965 memory\[10\]\[29\] VGND VGND VPWR VPWR net1174 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_86_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6267_ _2855_ _3184_ VGND VGND VPWR VPWR _3195_ sky130_fd_sc_hd__and2_1
X_3479_ _1155_ _1167_ _1175_ _1182_ _1184_ VGND VGND VPWR VPWR _1185_ sky130_fd_sc_hd__a221o_1
X_6198_ _2861_ _3154_ VGND VGND VPWR VPWR _3156_ sky130_fd_sc_hd__and2_1
X_5218_ _2466_ _2686_ _2687_ net1020 VGND VGND VPWR VPWR _0625_ sky130_fd_sc_hd__a22o_1
X_5149_ net1103 _2629_ _2630_ _2645_ VGND VGND VPWR VPWR _0598_ sky130_fd_sc_hd__a31o_1
XFILLER_0_39_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_85_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_122_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_25_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4520_ _2176_ _2177_ _1809_ VGND VGND VPWR VPWR _2178_ sky130_fd_sc_hd__mux2_1
XFILLER_0_103_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold217 memory\[16\]\[30\] VGND VGND VPWR VPWR net426 sky130_fd_sc_hd__dlygate4sd3_1
Xhold206 memory\[11\]\[1\] VGND VGND VPWR VPWR net415 sky130_fd_sc_hd__dlygate4sd3_1
X_4451_ _2110_ _2111_ _1903_ VGND VGND VPWR VPWR _2112_ sky130_fd_sc_hd__mux2_1
XFILLER_0_53_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold228 memory\[28\]\[23\] VGND VGND VPWR VPWR net437 sky130_fd_sc_hd__dlygate4sd3_1
X_7170_ clknet_leaf_68_clk _0761_ VGND VGND VPWR VPWR memory\[2\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_1_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold239 memory\[23\]\[7\] VGND VGND VPWR VPWR net448 sky130_fd_sc_hd__dlygate4sd3_1
X_4382_ memory\[12\]\[9\] memory\[13\]\[9\] memory\[14\]\[9\] memory\[15\]\[9\] _2045_
+ _2046_ VGND VGND VPWR VPWR _2047_ sky130_fd_sc_hd__mux4_1
X_6121_ net727 _3104_ _3109_ _3111_ VGND VGND VPWR VPWR _1104_ sky130_fd_sc_hd__a31o_1
XTAP_500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6052_ _2868_ _3066_ VGND VGND VPWR VPWR _3071_ sky130_fd_sc_hd__and2_1
X_5003_ net1174 _2543_ _2540_ VGND VGND VPWR VPWR _2551_ sky130_fd_sc_hd__and3_1
XTAP_577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6954_ clknet_leaf_51_clk _0545_ VGND VGND VPWR VPWR memory\[10\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_88_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5905_ _2872_ _2978_ VGND VGND VPWR VPWR _2986_ sky130_fd_sc_hd__and2_1
X_6885_ clknet_leaf_36_clk _0476_ VGND VGND VPWR VPWR memory\[28\]\[23\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_119_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_63_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5836_ _2474_ _2933_ _2945_ VGND VGND VPWR VPWR _0953_ sky130_fd_sc_hd__a21o_1
XFILLER_0_56_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5767_ _2638_ _2913_ _2914_ net265 VGND VGND VPWR VPWR _0915_ sky130_fd_sc_hd__a22o_1
XFILLER_0_17_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4718_ memory\[8\]\[27\] memory\[9\]\[27\] memory\[10\]\[27\] memory\[11\]\[27\]
+ _1837_ _1838_ VGND VGND VPWR VPWR _2365_ sky130_fd_sc_hd__mux4_1
X_5698_ net24 VGND VGND VPWR VPWR _2874_ sky130_fd_sc_hd__buf_4
X_7506_ clknet_leaf_12_clk _1065_ VGND VGND VPWR VPWR memory\[11\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_4649_ _2104_ _2299_ _2106_ VGND VGND VPWR VPWR _2300_ sky130_fd_sc_hd__o21a_1
X_7437_ clknet_leaf_73_clk net115 VGND VGND VPWR VPWR memory\[0\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_16_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7368_ clknet_leaf_31_clk _0927_ VGND VGND VPWR VPWR memory\[18\]\[25\] sky130_fd_sc_hd__dfxtp_1
Xhold762 memory\[27\]\[29\] VGND VGND VPWR VPWR net971 sky130_fd_sc_hd__dlygate4sd3_1
Xhold740 memory\[11\]\[11\] VGND VGND VPWR VPWR net949 sky130_fd_sc_hd__dlygate4sd3_1
X_5550__25 clknet_1_0__leaf__2786_ VGND VGND VPWR VPWR net170 sky130_fd_sc_hd__inv_2
Xhold751 memory\[9\]\[16\] VGND VGND VPWR VPWR net960 sky130_fd_sc_hd__dlygate4sd3_1
Xhold773 memory\[24\]\[0\] VGND VGND VPWR VPWR net982 sky130_fd_sc_hd__dlygate4sd3_1
X_7299_ clknet_leaf_54_clk _0858_ VGND VGND VPWR VPWR memory\[8\]\[20\] sky130_fd_sc_hd__dfxtp_1
Xhold784 memory\[5\]\[27\] VGND VGND VPWR VPWR net993 sky130_fd_sc_hd__dlygate4sd3_1
X_6319_ _2489_ _2490_ _2907_ VGND VGND VPWR VPWR _3224_ sky130_fd_sc_hd__and3_1
Xhold795 memory\[21\]\[18\] VGND VGND VPWR VPWR net1004 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_99_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_117_13 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_117_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3951_ memory\[0\]\[22\] memory\[1\]\[22\] memory\[2\]\[22\] memory\[3\]\[22\] _1363_
+ _1364_ VGND VGND VPWR VPWR _1635_ sky130_fd_sc_hd__mux4_1
XFILLER_0_58_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_555 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6670_ _2678_ _3376_ _3378_ net673 VGND VGND VPWR VPWR _0356_ sky130_fd_sc_hd__a22o_1
XFILLER_0_18_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3882_ _1567_ _1568_ _1472_ VGND VGND VPWR VPWR _1569_ sky130_fd_sc_hd__mux2_1
XFILLER_0_46_728 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5621_ _2663_ _2817_ VGND VGND VPWR VPWR _2822_ sky130_fd_sc_hd__and2_1
XFILLER_0_115_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4503_ _2097_ _2157_ _2159_ _2161_ _2066_ VGND VGND VPWR VPWR _2162_ sky130_fd_sc_hd__a221o_1
X_5483_ _2487_ _2766_ _2768_ net1019 VGND VGND VPWR VPWR _0804_ sky130_fd_sc_hd__a22o_1
XFILLER_0_14_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_111_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7222_ clknet_leaf_6_clk _0813_ VGND VGND VPWR VPWR memory\[31\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_22_680 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4434_ _2086_ _2089_ _2091_ _2095_ _2038_ VGND VGND VPWR VPWR _2096_ sky130_fd_sc_hd__a221o_1
XFILLER_0_41_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_111_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4365_ memory\[16\]\[9\] memory\[17\]\[9\] memory\[18\]\[9\] memory\[19\]\[9\] _2028_
+ _2029_ VGND VGND VPWR VPWR _2030_ sky130_fd_sc_hd__mux4_1
XFILLER_0_1_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_21_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7153_ clknet_leaf_104_clk _0744_ VGND VGND VPWR VPWR memory\[2\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_7084_ clknet_leaf_50_clk _0675_ VGND VGND VPWR VPWR memory\[4\]\[29\] sky130_fd_sc_hd__dfxtp_1
XTAP_341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6104_ net975 _3088_ _3095_ _3101_ VGND VGND VPWR VPWR _1097_ sky130_fd_sc_hd__a31o_1
X_4296_ _1808_ VGND VGND VPWR VPWR _1964_ sky130_fd_sc_hd__clkbuf_8
XTAP_385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6035_ _2851_ _3053_ VGND VGND VPWR VPWR _3061_ sky130_fd_sc_hd__and2_1
XTAP_396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6937_ clknet_leaf_76_clk _0528_ VGND VGND VPWR VPWR memory\[10\]\[10\] sky130_fd_sc_hd__dfxtp_1
XPHY_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6868_ clknet_leaf_7_clk _0459_ VGND VGND VPWR VPWR memory\[28\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_64_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_17_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5819_ _2466_ _2933_ _2936_ VGND VGND VPWR VPWR _0945_ sky130_fd_sc_hd__a21o_1
XFILLER_0_52_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6799_ _2623_ _3438_ _3440_ net543 VGND VGND VPWR VPWR _0428_ sky130_fd_sc_hd__a22o_1
XFILLER_0_44_282 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_114_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold570 memory\[1\]\[22\] VGND VGND VPWR VPWR net779 sky130_fd_sc_hd__dlygate4sd3_1
Xhold581 memory\[21\]\[3\] VGND VGND VPWR VPWR net790 sky130_fd_sc_hd__dlygate4sd3_1
Xhold592 memory\[18\]\[15\] VGND VGND VPWR VPWR net801 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_87_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_67_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_103_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_82_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_728 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_112_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_106_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput108 net108 VGND VGND VPWR VPWR data_out2[4] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_105_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_11_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_121_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4150_ _1796_ VGND VGND VPWR VPWR _1824_ sky130_fd_sc_hd__buf_4
Xoutput90 net90 VGND VGND VPWR VPWR data_out2[17] sky130_fd_sc_hd__clkbuf_4
X_4081_ memory\[12\]\[29\] memory\[13\]\[29\] memory\[14\]\[29\] memory\[15\]\[29\]
+ _1246_ _1247_ VGND VGND VPWR VPWR _1758_ sky130_fd_sc_hd__mux4_1
X_7840_ clknet_leaf_71_clk _0374_ VGND VGND VPWR VPWR memory\[9\]\[17\] sky130_fd_sc_hd__dfxtp_1
X_4983_ _2512_ VGND VGND VPWR VPWR _2540_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_58_330 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_7771_ clknet_leaf_85_clk _0305_ VGND VGND VPWR VPWR memory\[30\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_53_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3934_ memory\[12\]\[21\] memory\[13\]\[21\] memory\[14\]\[21\] memory\[15\]\[21\]
+ _1188_ _1190_ VGND VGND VPWR VPWR _1619_ sky130_fd_sc_hd__mux4_1
X_6722_ net28 _3414_ VGND VGND VPWR VPWR _3415_ sky130_fd_sc_hd__and2_1
XFILLER_0_85_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6653_ _2644_ _3380_ _3381_ net715 VGND VGND VPWR VPWR _0341_ sky130_fd_sc_hd__a22o_1
X_3865_ memory\[24\]\[18\] memory\[25\]\[18\] memory\[26\]\[18\] memory\[27\]\[18\]
+ _1551_ _1552_ VGND VGND VPWR VPWR _1553_ sky130_fd_sc_hd__mux4_1
XFILLER_0_34_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5604_ net1100 _2811_ _2803_ _2812_ VGND VGND VPWR VPWR _0854_ sky130_fd_sc_hd__a31o_1
X_3796_ _1153_ VGND VGND VPWR VPWR _1488_ sky130_fd_sc_hd__buf_4
X_6584_ net707 _3359_ _3351_ _3363_ VGND VGND VPWR VPWR _0290_ sky130_fd_sc_hd__a31o_1
XFILLER_0_6_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5466_ _2470_ _2770_ _2771_ net218 VGND VGND VPWR VPWR _0789_ sky130_fd_sc_hd__a22o_1
X_7205_ clknet_leaf_57_clk _0796_ VGND VGND VPWR VPWR memory\[14\]\[22\] sky130_fd_sc_hd__dfxtp_1
X_4417_ memory\[8\]\[11\] memory\[9\]\[11\] memory\[10\]\[11\] memory\[11\]\[11\]
+ _1913_ _1914_ VGND VGND VPWR VPWR _2080_ sky130_fd_sc_hd__mux4_1
X_5397_ _2483_ _2754_ _2755_ net245 VGND VGND VPWR VPWR _0736_ sky130_fd_sc_hd__a22o_1
X_4348_ net1 VGND VGND VPWR VPWR _2014_ sky130_fd_sc_hd__clkbuf_8
X_7136_ clknet_leaf_68_clk _0727_ VGND VGND VPWR VPWR memory\[3\]\[17\] sky130_fd_sc_hd__dfxtp_1
X_4279_ _1799_ VGND VGND VPWR VPWR _1948_ sky130_fd_sc_hd__buf_6
X_7067_ clknet_leaf_85_clk _0658_ VGND VGND VPWR VPWR memory\[4\]\[12\] sky130_fd_sc_hd__dfxtp_1
X_6018_ _3050_ VGND VGND VPWR VPWR _3051_ sky130_fd_sc_hd__clkbuf_4
XTAP_1304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_103_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_103_696 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_99_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_87_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1860 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3650_ memory\[20\]\[8\] memory\[21\]\[8\] memory\[22\]\[8\] memory\[23\]\[8\] _1312_
+ _1313_ VGND VGND VPWR VPWR _1348_ sky130_fd_sc_hd__mux4_1
X_3581_ memory\[28\]\[4\] memory\[29\]\[4\] memory\[30\]\[4\] memory\[31\]\[4\] _1178_
+ _1179_ VGND VGND VPWR VPWR _1283_ sky130_fd_sc_hd__mux4_1
X_5320_ _2489_ _2446_ _2736_ VGND VGND VPWR VPWR _2737_ sky130_fd_sc_hd__and3_1
XFILLER_0_2_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5251_ _2613_ _2695_ VGND VGND VPWR VPWR _2698_ sky130_fd_sc_hd__and2_1
X_4202_ _1871_ _1874_ VGND VGND VPWR VPWR _1875_ sky130_fd_sc_hd__or2_1
X_5182_ net795 _2652_ _2653_ _2668_ VGND VGND VPWR VPWR _0608_ sky130_fd_sc_hd__a31o_1
X_4133_ net3 VGND VGND VPWR VPWR _1807_ sky130_fd_sc_hd__inv_2
X_4064_ _1486_ _1741_ _1488_ VGND VGND VPWR VPWR _1742_ sky130_fd_sc_hd__o21a_1
XFILLER_0_3_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7823_ clknet_leaf_9_clk _0357_ VGND VGND VPWR VPWR memory\[9\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_7754_ clknet_leaf_27_clk _0288_ VGND VGND VPWR VPWR memory\[22\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_19_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6705_ net20 _3401_ VGND VGND VPWR VPWR _3405_ sky130_fd_sc_hd__and2_1
X_4966_ memory\[10\]\[12\] _2530_ _2526_ VGND VGND VPWR VPWR _2531_ sky130_fd_sc_hd__and3_1
X_3917_ _1483_ _1602_ VGND VGND VPWR VPWR _1603_ sky130_fd_sc_hd__or2_1
X_7685_ clknet_leaf_25_clk _0219_ VGND VGND VPWR VPWR memory\[21\]\[22\] sky130_fd_sc_hd__dfxtp_1
X_4897_ _2462_ _2494_ _2496_ net959 VGND VGND VPWR VPWR _0494_ sky130_fd_sc_hd__a22o_1
X_6636_ _2611_ _3377_ _3379_ net618 VGND VGND VPWR VPWR _0326_ sky130_fd_sc_hd__a22o_1
XFILLER_0_61_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3848_ memory\[4\]\[17\] memory\[5\]\[17\] memory\[6\]\[17\] memory\[7\]\[17\] _1360_
+ _1361_ VGND VGND VPWR VPWR _1537_ sky130_fd_sc_hd__mux4_1
XFILLER_0_104_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6567_ net1104 _3346_ _3351_ _3354_ VGND VGND VPWR VPWR _0282_ sky130_fd_sc_hd__a31o_1
XFILLER_0_61_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3779_ memory\[16\]\[14\] memory\[17\]\[14\] memory\[18\]\[14\] memory\[19\]\[14\]
+ _1349_ _1350_ VGND VGND VPWR VPWR _1471_ sky130_fd_sc_hd__mux4_1
XFILLER_0_6_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_6_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5518_ _2663_ _2781_ _2782_ net381 VGND VGND VPWR VPWR _0830_ sky130_fd_sc_hd__a22o_1
X_6498_ _2893_ _3308_ VGND VGND VPWR VPWR _3314_ sky130_fd_sc_hd__and2_1
X_5449_ _2439_ _2767_ _2769_ net343 VGND VGND VPWR VPWR _0774_ sky130_fd_sc_hd__a22o_1
X_7119_ clknet_leaf_102_clk _0710_ VGND VGND VPWR VPWR memory\[3\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_97_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_100_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_907 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_918 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_929 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4820_ net42 VGND VGND VPWR VPWR _2457_ sky130_fd_sc_hd__buf_4
XTAP_1690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4751_ memory\[4\]\[29\] memory\[5\]\[29\] memory\[6\]\[29\] memory\[7\]\[29\] _1813_
+ _1815_ VGND VGND VPWR VPWR _2396_ sky130_fd_sc_hd__mux4_1
XFILLER_0_83_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4682_ _1976_ _2330_ _1796_ VGND VGND VPWR VPWR _2331_ sky130_fd_sc_hd__o21a_1
X_7470_ clknet_leaf_46_clk _1029_ VGND VGND VPWR VPWR memory\[1\]\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_55_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3702_ _1170_ VGND VGND VPWR VPWR _1398_ sky130_fd_sc_hd__buf_4
X_6421_ net621 _3262_ _3263_ _3269_ VGND VGND VPWR VPWR _0221_ sky130_fd_sc_hd__a31o_1
X_3633_ memory\[16\]\[7\] memory\[17\]\[7\] memory\[18\]\[7\] memory\[19\]\[7\] _1161_
+ _1162_ VGND VGND VPWR VPWR _1332_ sky130_fd_sc_hd__mux4_1
XFILLER_0_43_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_70_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_12_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6352_ _2663_ _3231_ _3232_ net391 VGND VGND VPWR VPWR _0189_ sky130_fd_sc_hd__a22o_1
X_3564_ _1186_ _1266_ VGND VGND VPWR VPWR _1267_ sky130_fd_sc_hd__or2_1
X_5303_ _2665_ _2721_ VGND VGND VPWR VPWR _2727_ sky130_fd_sc_hd__and2_1
XFILLER_0_59_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6283_ net915 _3200_ _3196_ _3204_ VGND VGND VPWR VPWR _0148_ sky130_fd_sc_hd__a31o_1
X_3495_ memory\[4\]\[0\] memory\[5\]\[0\] memory\[6\]\[0\] memory\[7\]\[0\] _1199_
+ _1200_ VGND VGND VPWR VPWR _1201_ sky130_fd_sc_hd__mux4_2
X_5234_ _2482_ _2688_ _2689_ net413 VGND VGND VPWR VPWR _0639_ sky130_fd_sc_hd__a22o_1
X_5165_ net29 VGND VGND VPWR VPWR _2657_ sky130_fd_sc_hd__buf_4
X_4116_ _1186_ _1790_ VGND VGND VPWR VPWR _1791_ sky130_fd_sc_hd__or2_1
XFILLER_0_38_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5096_ _2608_ VGND VGND VPWR VPWR _2609_ sky130_fd_sc_hd__buf_2
X_4047_ _1720_ _1722_ _1725_ _1154_ _1606_ VGND VGND VPWR VPWR _1726_ sky130_fd_sc_hd__a221o_1
XPHY_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7806_ clknet_leaf_67_clk _0340_ VGND VGND VPWR VPWR memory\[12\]\[15\] sky130_fd_sc_hd__dfxtp_1
XPHY_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5998_ _2888_ _3036_ VGND VGND VPWR VPWR _3040_ sky130_fd_sc_hd__and2_1
XFILLER_0_93_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4949_ _2458_ _2505_ _2520_ VGND VGND VPWR VPWR _0523_ sky130_fd_sc_hd__a21o_1
X_7737_ clknet_leaf_109_clk _0271_ VGND VGND VPWR VPWR memory\[22\]\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_19_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_117_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7668_ clknet_leaf_111_clk _0202_ VGND VGND VPWR VPWR memory\[21\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_34_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6619_ _2657_ _3373_ _3374_ net361 VGND VGND VPWR VPWR _0314_ sky130_fd_sc_hd__a22o_1
XFILLER_0_62_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_104_224 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_61_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_155 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_15_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7599_ clknet_leaf_4_clk _0133_ VGND VGND VPWR VPWR memory\[27\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_30_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_108_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5556__31 clknet_1_0__leaf__2786_ VGND VGND VPWR VPWR net176 sky130_fd_sc_hd__inv_2
XFILLER_0_5_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_53_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_111_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_4_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_9 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6970_ clknet_leaf_84_clk _0561_ VGND VGND VPWR VPWR memory\[6\]\[11\] sky130_fd_sc_hd__dfxtp_1
X_5921_ net779 _2994_ _2990_ _2995_ VGND VGND VPWR VPWR _1020_ sky130_fd_sc_hd__a31o_1
XFILLER_0_88_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5852_ _2483_ _2946_ _2954_ VGND VGND VPWR VPWR _0960_ sky130_fd_sc_hd__a21o_1
XFILLER_0_75_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_1_0__f__2787_ clknet_0__2787_ VGND VGND VPWR VPWR clknet_1_0__leaf__2787_
+ sky130_fd_sc_hd__clkbuf_16
X_5783_ _2669_ _2915_ _2916_ net996 VGND VGND VPWR VPWR _0929_ sky130_fd_sc_hd__a22o_1
X_4803_ net13 VGND VGND VPWR VPWR _2445_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_75_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4734_ _1811_ _2379_ VGND VGND VPWR VPWR _2380_ sky130_fd_sc_hd__or2_1
X_7522_ clknet_leaf_71_clk _1081_ VGND VGND VPWR VPWR memory\[11\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_16_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4665_ _2101_ _2314_ VGND VGND VPWR VPWR _2315_ sky130_fd_sc_hd__or2_1
X_7453_ clknet_leaf_68_clk _1012_ VGND VGND VPWR VPWR memory\[1\]\[14\] sky130_fd_sc_hd__dfxtp_1
X_4596_ _2097_ _2244_ _2246_ _2248_ _2249_ VGND VGND VPWR VPWR _2250_ sky130_fd_sc_hd__a221o_1
Xhold900 memory\[10\]\[19\] VGND VGND VPWR VPWR net1109 sky130_fd_sc_hd__dlygate4sd3_1
Xhold922 memory\[6\]\[30\] VGND VGND VPWR VPWR net1131 sky130_fd_sc_hd__dlygate4sd3_1
Xhold911 memory\[10\]\[7\] VGND VGND VPWR VPWR net1120 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6404_ net769 _3249_ _3250_ _3259_ VGND VGND VPWR VPWR _0214_ sky130_fd_sc_hd__a31o_1
X_7384_ clknet_leaf_113_clk _0943_ VGND VGND VPWR VPWR memory\[25\]\[9\] sky130_fd_sc_hd__dfxtp_1
X_3616_ _1314_ _1315_ _1279_ VGND VGND VPWR VPWR _1316_ sky130_fd_sc_hd__mux2_1
Xhold955 memory\[10\]\[26\] VGND VGND VPWR VPWR net1164 sky130_fd_sc_hd__dlygate4sd3_1
Xhold933 memory\[6\]\[29\] VGND VGND VPWR VPWR net1142 sky130_fd_sc_hd__dlygate4sd3_1
X_3547_ _1187_ VGND VGND VPWR VPWR _1251_ sky130_fd_sc_hd__clkbuf_8
Xhold944 memory\[25\]\[10\] VGND VGND VPWR VPWR net1153 sky130_fd_sc_hd__dlygate4sd3_1
X_6335_ _3227_ VGND VGND VPWR VPWR _3230_ sky130_fd_sc_hd__buf_4
Xhold966 memory\[25\]\[20\] VGND VGND VPWR VPWR net1175 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_86_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6266_ net928 _3187_ _3182_ _3194_ VGND VGND VPWR VPWR _0141_ sky130_fd_sc_hd__a31o_1
X_3478_ _1183_ VGND VGND VPWR VPWR _1184_ sky130_fd_sc_hd__clkbuf_4
X_6197_ net1009 _3146_ _3153_ _3155_ VGND VGND VPWR VPWR _1136_ sky130_fd_sc_hd__a31o_1
X_5217_ _2463_ _2686_ _2687_ net922 VGND VGND VPWR VPWR _0624_ sky130_fd_sc_hd__a22o_1
X_5148_ _2644_ _2632_ VGND VGND VPWR VPWR _2645_ sky130_fd_sc_hd__and2_1
X_5079_ _2485_ _2584_ _2595_ VGND VGND VPWR VPWR _0578_ sky130_fd_sc_hd__a21o_1
XFILLER_0_94_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_81_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_105_522 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_62_453 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_120_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_106_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_15_13 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_15_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_85_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_707 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_45_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_122_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_5_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_26_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold207 memory\[13\]\[22\] VGND VGND VPWR VPWR net416 sky130_fd_sc_hd__dlygate4sd3_1
X_4450_ memory\[16\]\[13\] memory\[17\]\[13\] memory\[18\]\[13\] memory\[19\]\[13\]
+ _2028_ _2029_ VGND VGND VPWR VPWR _2111_ sky130_fd_sc_hd__mux4_1
XFILLER_0_40_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_111_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4381_ _1832_ VGND VGND VPWR VPWR _2046_ sky130_fd_sc_hd__clkbuf_8
Xhold229 memory\[15\]\[2\] VGND VGND VPWR VPWR net438 sky130_fd_sc_hd__dlygate4sd3_1
Xhold218 memory\[24\]\[2\] VGND VGND VPWR VPWR net427 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_111_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6120_ _2858_ _3110_ VGND VGND VPWR VPWR _3111_ sky130_fd_sc_hd__and2_1
XFILLER_0_21_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6051_ net327 _3062_ _3065_ _3070_ VGND VGND VPWR VPWR _1075_ sky130_fd_sc_hd__a31o_1
XTAP_545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5002_ _2485_ _2539_ _2550_ VGND VGND VPWR VPWR _0546_ sky130_fd_sc_hd__a21o_1
XFILLER_0_56_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6953_ clknet_leaf_52_clk _0544_ VGND VGND VPWR VPWR memory\[10\]\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_72_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6884_ clknet_leaf_37_clk _0475_ VGND VGND VPWR VPWR memory\[28\]\[22\] sky130_fd_sc_hd__dfxtp_1
X_5904_ net890 _2981_ _2977_ _2985_ VGND VGND VPWR VPWR _1013_ sky130_fd_sc_hd__a31o_1
XFILLER_0_119_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5835_ net1111 _2943_ _2934_ VGND VGND VPWR VPWR _2945_ sky130_fd_sc_hd__and3_1
XFILLER_0_119_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_118_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5766_ _2636_ _2913_ _2914_ net241 VGND VGND VPWR VPWR _0914_ sky130_fd_sc_hd__a22o_1
X_4717_ _2362_ _2363_ _2191_ VGND VGND VPWR VPWR _2364_ sky130_fd_sc_hd__mux2_1
XFILLER_0_16_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7505_ clknet_leaf_11_clk _1064_ VGND VGND VPWR VPWR memory\[11\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_5697_ net782 _2867_ _2857_ _2873_ VGND VGND VPWR VPWR _0886_ sky130_fd_sc_hd__a31o_1
X_5535__12 clknet_1_0__leaf__2784_ VGND VGND VPWR VPWR net157 sky130_fd_sc_hd__inv_2
X_7436_ clknet_leaf_58_clk net116 VGND VGND VPWR VPWR memory\[0\]\[29\] sky130_fd_sc_hd__dfxtp_1
X_4648_ memory\[12\]\[23\] memory\[13\]\[23\] memory\[14\]\[23\] memory\[15\]\[23\]
+ _2045_ _2046_ VGND VGND VPWR VPWR _2299_ sky130_fd_sc_hd__mux4_1
XFILLER_0_112_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold730 memory\[7\]\[20\] VGND VGND VPWR VPWR net939 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_31_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7367_ clknet_leaf_32_clk _0926_ VGND VGND VPWR VPWR memory\[18\]\[24\] sky130_fd_sc_hd__dfxtp_1
Xhold752 memory\[18\]\[22\] VGND VGND VPWR VPWR net961 sky130_fd_sc_hd__dlygate4sd3_1
X_4579_ _2233_ VGND VGND VPWR VPWR _0042_ sky130_fd_sc_hd__clkbuf_1
Xhold763 memory\[23\]\[17\] VGND VGND VPWR VPWR net972 sky130_fd_sc_hd__dlygate4sd3_1
Xhold741 memory\[16\]\[8\] VGND VGND VPWR VPWR net950 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_97_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold774 memory\[8\]\[31\] VGND VGND VPWR VPWR net983 sky130_fd_sc_hd__dlygate4sd3_1
X_7298_ clknet_leaf_71_clk _0857_ VGND VGND VPWR VPWR memory\[8\]\[19\] sky130_fd_sc_hd__dfxtp_1
X_6318_ net649 _3213_ _3181_ _3223_ VGND VGND VPWR VPWR _0164_ sky130_fd_sc_hd__a31o_1
Xhold785 memory\[16\]\[16\] VGND VGND VPWR VPWR net994 sky130_fd_sc_hd__dlygate4sd3_1
Xhold796 memory\[3\]\[4\] VGND VGND VPWR VPWR net1005 sky130_fd_sc_hd__dlygate4sd3_1
X_6249_ net639 _3172_ _3182_ _3185_ VGND VGND VPWR VPWR _0133_ sky130_fd_sc_hd__a31o_1
XFILLER_0_98_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_86_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_203 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_39_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_109_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_109_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_117_25 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_117_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold90 memory\[2\]\[23\] VGND VGND VPWR VPWR net299 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_89_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3950_ memory\[4\]\[22\] memory\[5\]\[22\] memory\[6\]\[22\] memory\[7\]\[22\] _1360_
+ _1361_ VGND VGND VPWR VPWR _1634_ sky130_fd_sc_hd__mux4_1
XFILLER_0_85_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3881_ memory\[16\]\[19\] memory\[17\]\[19\] memory\[18\]\[19\] memory\[19\]\[19\]
+ _1547_ _1548_ VGND VGND VPWR VPWR _1568_ sky130_fd_sc_hd__mux4_1
X_5620_ net794 _2811_ _2816_ _2821_ VGND VGND VPWR VPWR _0861_ sky130_fd_sc_hd__a31o_1
XFILLER_0_73_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4502_ _2104_ _2160_ _2106_ VGND VGND VPWR VPWR _2161_ sky130_fd_sc_hd__o21a_1
XFILLER_0_14_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5482_ _2486_ _2772_ _2773_ net932 VGND VGND VPWR VPWR _0803_ sky130_fd_sc_hd__a22o_1
X_7221_ clknet_leaf_7_clk _0812_ VGND VGND VPWR VPWR memory\[31\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_13_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4433_ _1820_ _2094_ _1824_ VGND VGND VPWR VPWR _2095_ sky130_fd_sc_hd__o21a_1
XFILLER_0_22_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4364_ _1801_ VGND VGND VPWR VPWR _2029_ sky130_fd_sc_hd__clkbuf_8
X_7152_ clknet_leaf_11_clk _0743_ VGND VGND VPWR VPWR memory\[2\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_7083_ clknet_leaf_50_clk _0674_ VGND VGND VPWR VPWR memory\[4\]\[28\] sky130_fd_sc_hd__dfxtp_1
XTAP_342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6103_ _2842_ _3097_ VGND VGND VPWR VPWR _3101_ sky130_fd_sc_hd__and2_1
XFILLER_0_1_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4295_ _1959_ _1962_ VGND VGND VPWR VPWR _1963_ sky130_fd_sc_hd__or2_1
XTAP_375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6034_ net1056 _3047_ _3051_ _3060_ VGND VGND VPWR VPWR _1068_ sky130_fd_sc_hd__a31o_1
XTAP_397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_49_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6936_ clknet_leaf_14_clk _0527_ VGND VGND VPWR VPWR memory\[10\]\[9\] sky130_fd_sc_hd__dfxtp_1
XPHY_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6867_ clknet_leaf_4_clk _0458_ VGND VGND VPWR VPWR memory\[28\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_107_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_106_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6798_ _2621_ _3438_ _3440_ net926 VGND VGND VPWR VPWR _0427_ sky130_fd_sc_hd__a22o_1
XFILLER_0_8_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5818_ net1140 _2930_ _2934_ VGND VGND VPWR VPWR _2936_ sky130_fd_sc_hd__and3_1
XFILLER_0_29_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_17_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5749_ _2909_ VGND VGND VPWR VPWR _2910_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_106_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_102_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7419_ clknet_leaf_83_clk net133 VGND VGND VPWR VPWR memory\[0\]\[12\] sky130_fd_sc_hd__dfxtp_1
Xhold571 memory\[1\]\[17\] VGND VGND VPWR VPWR net780 sky130_fd_sc_hd__dlygate4sd3_1
Xhold560 memory\[21\]\[17\] VGND VGND VPWR VPWR net769 sky130_fd_sc_hd__dlygate4sd3_1
Xhold582 memory\[22\]\[28\] VGND VGND VPWR VPWR net791 sky130_fd_sc_hd__dlygate4sd3_1
Xhold593 memory\[1\]\[1\] VGND VGND VPWR VPWR net802 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_86_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_79_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_103_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_112_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_106_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_2_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput109 net109 VGND VGND VPWR VPWR data_out2[5] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_23_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_120_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_120_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_121_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput91 net91 VGND VGND VPWR VPWR data_out2[18] sky130_fd_sc_hd__clkbuf_4
Xoutput80 net80 VGND VGND VPWR VPWR data_out1[8] sky130_fd_sc_hd__clkbuf_4
X_4080_ _1186_ _1756_ VGND VGND VPWR VPWR _1757_ sky130_fd_sc_hd__or2_1
XFILLER_0_53_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4982_ _2504_ VGND VGND VPWR VPWR _2539_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_58_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7770_ clknet_leaf_78_clk _0304_ VGND VGND VPWR VPWR memory\[30\]\[11\] sky130_fd_sc_hd__dfxtp_1
X_3933_ _1168_ _1617_ VGND VGND VPWR VPWR _1618_ sky130_fd_sc_hd__or2_1
X_6721_ _3387_ VGND VGND VPWR VPWR _3414_ sky130_fd_sc_hd__clkbuf_4
X_3864_ _1189_ VGND VGND VPWR VPWR _1552_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_73_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6652_ _2642_ _3380_ _3381_ net644 VGND VGND VPWR VPWR _0340_ sky130_fd_sc_hd__a22o_1
XFILLER_0_6_612 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5603_ _2644_ _2804_ VGND VGND VPWR VPWR _2812_ sky130_fd_sc_hd__and2_1
XFILLER_0_6_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6583_ _2901_ _3352_ VGND VGND VPWR VPWR _3363_ sky130_fd_sc_hd__and2_1
X_3795_ memory\[12\]\[14\] memory\[13\]\[14\] memory\[14\]\[14\] memory\[15\]\[14\]
+ _1430_ _1431_ VGND VGND VPWR VPWR _1487_ sky130_fd_sc_hd__mux4_1
X_5465_ _2469_ _2770_ _2771_ net749 VGND VGND VPWR VPWR _0788_ sky130_fd_sc_hd__a22o_1
X_7204_ clknet_leaf_53_clk _0795_ VGND VGND VPWR VPWR memory\[14\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_111_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_68_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_41_286 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4416_ _2077_ _2078_ _1869_ VGND VGND VPWR VPWR _2079_ sky130_fd_sc_hd__mux2_1
X_5396_ _2482_ _2754_ _2755_ net703 VGND VGND VPWR VPWR _0735_ sky130_fd_sc_hd__a22o_1
X_7135_ clknet_leaf_81_clk _0726_ VGND VGND VPWR VPWR memory\[3\]\[16\] sky130_fd_sc_hd__dfxtp_1
X_4347_ _2007_ _2009_ _2012_ _1978_ _1827_ VGND VGND VPWR VPWR _2013_ sky130_fd_sc_hd__a221o_1
X_7066_ clknet_leaf_84_clk _0657_ VGND VGND VPWR VPWR memory\[4\]\[11\] sky130_fd_sc_hd__dfxtp_1
X_4278_ _1798_ _1942_ _1944_ _1946_ _1827_ VGND VGND VPWR VPWR _1947_ sky130_fd_sc_hd__a221o_1
X_6017_ _2831_ _2511_ VGND VGND VPWR VPWR _3050_ sky130_fd_sc_hd__nand2_2
XTAP_1305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6919_ clknet_leaf_54_clk _0510_ VGND VGND VPWR VPWR memory\[15\]\[25\] sky130_fd_sc_hd__dfxtp_1
XTAP_1349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7899_ clknet_leaf_90_clk _0433_ VGND VGND VPWR VPWR memory\[17\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_37_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_115_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_102_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold390 memory\[23\]\[5\] VGND VGND VPWR VPWR net599 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_90_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1861 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1850 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_3_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3580_ _1169_ _1281_ VGND VGND VPWR VPWR _1282_ sky130_fd_sc_hd__or2_1
XFILLER_0_51_540 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_51_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5250_ net991 _2675_ _2693_ _2697_ VGND VGND VPWR VPWR _0647_ sky130_fd_sc_hd__a31o_1
X_4201_ memory\[8\]\[1\] memory\[9\]\[1\] memory\[10\]\[1\] memory\[11\]\[1\] _1872_
+ _1873_ VGND VGND VPWR VPWR _1874_ sky130_fd_sc_hd__mux4_1
X_5181_ _2667_ _2655_ VGND VGND VPWR VPWR _2668_ sky130_fd_sc_hd__and2_1
X_4132_ memory\[16\]\[0\] memory\[17\]\[0\] memory\[18\]\[0\] memory\[19\]\[0\] _1804_
+ _1805_ VGND VGND VPWR VPWR _1806_ sky130_fd_sc_hd__mux4_1
X_4063_ memory\[12\]\[28\] memory\[13\]\[28\] memory\[14\]\[28\] memory\[15\]\[28\]
+ _1246_ _1247_ VGND VGND VPWR VPWR _1741_ sky130_fd_sc_hd__mux4_1
XFILLER_0_78_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7822_ clknet_leaf_41_clk _0356_ VGND VGND VPWR VPWR memory\[12\]\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_78_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4965_ _2529_ VGND VGND VPWR VPWR _2530_ sky130_fd_sc_hd__buf_2
X_7753_ clknet_leaf_24_clk _0287_ VGND VGND VPWR VPWR memory\[22\]\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_80_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3916_ memory\[8\]\[20\] memory\[9\]\[20\] memory\[10\]\[20\] memory\[11\]\[20\]
+ _1426_ _1427_ VGND VGND VPWR VPWR _1602_ sky130_fd_sc_hd__mux4_1
XFILLER_0_74_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6704_ net548 _3393_ _3400_ _3404_ VGND VGND VPWR VPWR _0369_ sky130_fd_sc_hd__a31o_1
X_7684_ clknet_leaf_25_clk _0218_ VGND VGND VPWR VPWR memory\[21\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_80_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4896_ _2461_ _2494_ _2496_ net489 VGND VGND VPWR VPWR _0493_ sky130_fd_sc_hd__a22o_1
X_6635_ _2607_ _3377_ _3379_ net799 VGND VGND VPWR VPWR _0325_ sky130_fd_sc_hd__a22o_1
X_3847_ _1390_ _1531_ _1533_ _1535_ _1403_ VGND VGND VPWR VPWR _1536_ sky130_fd_sc_hd__a221o_1
XFILLER_0_34_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6566_ _2884_ _3352_ VGND VGND VPWR VPWR _3354_ sky130_fd_sc_hd__and2_1
XFILLER_0_61_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3778_ memory\[20\]\[14\] memory\[21\]\[14\] memory\[22\]\[14\] memory\[23\]\[14\]
+ _1312_ _1313_ VGND VGND VPWR VPWR _1470_ sky130_fd_sc_hd__mux4_1
X_5517_ _2661_ _2781_ _2782_ net301 VGND VGND VPWR VPWR _0829_ sky130_fd_sc_hd__a22o_1
XFILLER_0_6_497 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_30_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6497_ net951 _3304_ _3307_ _3313_ VGND VGND VPWR VPWR _0253_ sky130_fd_sc_hd__a31o_1
X_5448_ _2768_ VGND VGND VPWR VPWR _2769_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_2_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_100_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5379_ _2463_ _2752_ _2753_ net485 VGND VGND VPWR VPWR _0720_ sky130_fd_sc_hd__a22o_1
X_7118_ clknet_leaf_18_clk _0709_ VGND VGND VPWR VPWR memory\[29\]\[31\] sky130_fd_sc_hd__dfxtp_1
X_7049_ clknet_leaf_32_clk _0640_ VGND VGND VPWR VPWR memory\[16\]\[26\] sky130_fd_sc_hd__dfxtp_1
XTAP_1113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_108_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_49_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_122_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_908 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_919 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6850__57 clknet_1_0__leaf__3446_ VGND VGND VPWR VPWR net202 sky130_fd_sc_hd__inv_2
XFILLER_0_47_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_632 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4750_ _2389_ _2391_ _2394_ _1862_ _1826_ VGND VGND VPWR VPWR _2395_ sky130_fd_sc_hd__a221o_1
XFILLER_0_71_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4681_ memory\[12\]\[25\] memory\[13\]\[25\] memory\[14\]\[25\] memory\[15\]\[25\]
+ _1973_ _1974_ VGND VGND VPWR VPWR _2330_ sky130_fd_sc_hd__mux4_1
X_3701_ _1176_ VGND VGND VPWR VPWR _1397_ sky130_fd_sc_hd__clkbuf_4
X_6420_ _2891_ _3264_ VGND VGND VPWR VPWR _3269_ sky130_fd_sc_hd__and2_1
X_3632_ memory\[20\]\[7\] memory\[21\]\[7\] memory\[22\]\[7\] memory\[23\]\[7\] _1312_
+ _1313_ VGND VGND VPWR VPWR _1331_ sky130_fd_sc_hd__mux4_1
XFILLER_0_43_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_113_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6351_ _2661_ _3231_ _3232_ net625 VGND VGND VPWR VPWR _0188_ sky130_fd_sc_hd__a22o_1
XFILLER_0_12_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5302_ net1097 _2717_ _2720_ _2726_ VGND VGND VPWR VPWR _0670_ sky130_fd_sc_hd__a31o_1
X_3563_ memory\[8\]\[3\] memory\[9\]\[3\] memory\[10\]\[3\] memory\[11\]\[3\] _1188_
+ _1190_ VGND VGND VPWR VPWR _1266_ sky130_fd_sc_hd__mux4_1
X_6282_ _2870_ _3197_ VGND VGND VPWR VPWR _3204_ sky130_fd_sc_hd__and2_1
X_3494_ _1158_ VGND VGND VPWR VPWR _1200_ sky130_fd_sc_hd__buf_4
X_5233_ _2481_ _2688_ _2689_ net259 VGND VGND VPWR VPWR _0638_ sky130_fd_sc_hd__a22o_1
X_5164_ net837 _2652_ _2653_ _2656_ VGND VGND VPWR VPWR _0602_ sky130_fd_sc_hd__a31o_1
X_4115_ memory\[8\]\[31\] memory\[9\]\[31\] memory\[10\]\[31\] memory\[11\]\[31\]
+ _1194_ _1195_ VGND VGND VPWR VPWR _1790_ sky130_fd_sc_hd__mux4_1
X_5095_ _2510_ _2501_ _2603_ VGND VGND VPWR VPWR _2608_ sky130_fd_sc_hd__and3_2
X_4046_ _1723_ _1724_ _1166_ VGND VGND VPWR VPWR _1725_ sky130_fd_sc_hd__mux2_1
XPHY_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7805_ clknet_leaf_66_clk _0339_ VGND VGND VPWR VPWR memory\[12\]\[14\] sky130_fd_sc_hd__dfxtp_1
XPHY_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5997_ net1089 _3034_ _3035_ _3039_ VGND VGND VPWR VPWR _1052_ sky130_fd_sc_hd__a31o_1
XFILLER_0_93_237 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_19_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4948_ net1106 _2516_ _2513_ VGND VGND VPWR VPWR _2520_ sky130_fd_sc_hd__and3_1
X_7736_ clknet_leaf_110_clk _0270_ VGND VGND VPWR VPWR memory\[22\]\[9\] sky130_fd_sc_hd__dfxtp_1
X_4879_ _2488_ _2448_ _2452_ net709 VGND VGND VPWR VPWR _0484_ sky130_fd_sc_hd__a22o_1
XFILLER_0_74_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7667_ clknet_leaf_115_clk _0201_ VGND VGND VPWR VPWR memory\[21\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_6618_ _2654_ _3373_ _3374_ net473 VGND VGND VPWR VPWR _0313_ sky130_fd_sc_hd__a22o_1
XFILLER_0_62_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_104_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_61_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7598_ clknet_leaf_7_clk _0132_ VGND VGND VPWR VPWR memory\[23\]\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_61_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6549_ _2868_ _3339_ VGND VGND VPWR VPWR _3344_ sky130_fd_sc_hd__and2_1
XFILLER_0_100_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_108_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_112_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_111_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_80_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_110_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5920_ _2886_ _2991_ VGND VGND VPWR VPWR _2995_ sky130_fd_sc_hd__and2_1
X_5851_ net1137 _2943_ _2947_ VGND VGND VPWR VPWR _2954_ sky130_fd_sc_hd__and3_1
Xclkbuf_1_0__f__2786_ clknet_0__2786_ VGND VGND VPWR VPWR clknet_1_0__leaf__2786_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_8_504 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_0_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_118_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5782_ _2667_ _2915_ _2916_ net735 VGND VGND VPWR VPWR _0928_ sky130_fd_sc_hd__a22o_1
X_4802_ net14 VGND VGND VPWR VPWR _2444_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_61_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4733_ memory\[8\]\[28\] memory\[9\]\[28\] memory\[10\]\[28\] memory\[11\]\[28\]
+ _1948_ _1949_ VGND VGND VPWR VPWR _2379_ sky130_fd_sc_hd__mux4_1
X_7521_ clknet_leaf_73_clk _1080_ VGND VGND VPWR VPWR memory\[11\]\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_16_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_83_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7452_ clknet_leaf_82_clk _1011_ VGND VGND VPWR VPWR memory\[1\]\[13\] sky130_fd_sc_hd__dfxtp_1
X_4664_ memory\[8\]\[24\] memory\[9\]\[24\] memory\[10\]\[24\] memory\[11\]\[24\]
+ _1837_ _1838_ VGND VGND VPWR VPWR _2314_ sky130_fd_sc_hd__mux4_1
XFILLER_0_71_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6403_ _2874_ _3251_ VGND VGND VPWR VPWR _3259_ sky130_fd_sc_hd__and2_1
XFILLER_0_43_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold912 memory\[25\]\[23\] VGND VGND VPWR VPWR net1121 sky130_fd_sc_hd__dlygate4sd3_1
X_4595_ net5 VGND VGND VPWR VPWR _2249_ sky130_fd_sc_hd__clkbuf_4
Xhold901 memory\[5\]\[3\] VGND VGND VPWR VPWR net1110 sky130_fd_sc_hd__dlygate4sd3_1
X_3615_ memory\[16\]\[6\] memory\[17\]\[6\] memory\[18\]\[6\] memory\[19\]\[6\] _1161_
+ _1162_ VGND VGND VPWR VPWR _1315_ sky130_fd_sc_hd__mux4_1
X_7383_ clknet_leaf_105_clk _0942_ VGND VGND VPWR VPWR memory\[25\]\[8\] sky130_fd_sc_hd__dfxtp_1
Xhold934 memory\[25\]\[22\] VGND VGND VPWR VPWR net1143 sky130_fd_sc_hd__dlygate4sd3_1
X_3546_ _1165_ VGND VGND VPWR VPWR _1250_ sky130_fd_sc_hd__buf_4
X_6334_ _3225_ VGND VGND VPWR VPWR _3229_ sky130_fd_sc_hd__buf_4
Xhold923 memory\[6\]\[10\] VGND VGND VPWR VPWR net1132 sky130_fd_sc_hd__dlygate4sd3_1
Xhold945 memory\[6\]\[12\] VGND VGND VPWR VPWR net1154 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold956 memory\[25\]\[17\] VGND VGND VPWR VPWR net1165 sky130_fd_sc_hd__dlygate4sd3_1
X_6265_ _2853_ _3184_ VGND VGND VPWR VPWR _3194_ sky130_fd_sc_hd__and2_1
X_3477_ net10 VGND VGND VPWR VPWR _1183_ sky130_fd_sc_hd__clkinv_4
X_5216_ _2684_ VGND VGND VPWR VPWR _2687_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_50_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6196_ _2858_ _3154_ VGND VGND VPWR VPWR _3155_ sky130_fd_sc_hd__and2_1
X_5147_ net23 VGND VGND VPWR VPWR _2644_ sky130_fd_sc_hd__buf_4
XFILLER_0_98_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5078_ net1123 _2585_ _2586_ VGND VGND VPWR VPWR _2595_ sky130_fd_sc_hd__and3_1
X_4029_ _1479_ _1704_ _1706_ _1708_ _1606_ VGND VGND VPWR VPWR _1709_ sky130_fd_sc_hd__a221o_1
XFILLER_0_109_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7719_ clknet_leaf_64_clk _0253_ VGND VGND VPWR VPWR memory\[5\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_19_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_105_534 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_106_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_122_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_72_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_31_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold208 memory\[17\]\[16\] VGND VGND VPWR VPWR net417 sky130_fd_sc_hd__dlygate4sd3_1
X_4380_ _1830_ VGND VGND VPWR VPWR _2045_ sky130_fd_sc_hd__buf_6
Xhold219 memory\[19\]\[4\] VGND VGND VPWR VPWR net428 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6050_ _2865_ _3066_ VGND VGND VPWR VPWR _3070_ sky130_fd_sc_hd__and2_1
XTAP_535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5001_ net1163 _2543_ _2540_ VGND VGND VPWR VPWR _2550_ sky130_fd_sc_hd__and3_1
XTAP_568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6952_ clknet_leaf_53_clk _0543_ VGND VGND VPWR VPWR memory\[10\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_88_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6883_ clknet_leaf_37_clk _0474_ VGND VGND VPWR VPWR memory\[28\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_76_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5903_ _2870_ _2978_ VGND VGND VPWR VPWR _2985_ sky130_fd_sc_hd__and2_1
XFILLER_0_48_215 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_8_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5834_ _2473_ _2933_ _2944_ VGND VGND VPWR VPWR _0952_ sky130_fd_sc_hd__a21o_1
XFILLER_0_63_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_8_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5765_ _2634_ _2913_ _2914_ net264 VGND VGND VPWR VPWR _0913_ sky130_fd_sc_hd__a22o_1
X_4716_ memory\[0\]\[27\] memory\[1\]\[27\] memory\[2\]\[27\] memory\[3\]\[27\] _1863_
+ _1864_ VGND VGND VPWR VPWR _2363_ sky130_fd_sc_hd__mux4_1
XFILLER_0_98_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_7504_ clknet_leaf_15_clk _1063_ VGND VGND VPWR VPWR memory\[11\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_5696_ _2872_ _2859_ VGND VGND VPWR VPWR _2873_ sky130_fd_sc_hd__and2_1
XFILLER_0_44_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4647_ _2101_ _2297_ VGND VGND VPWR VPWR _2298_ sky130_fd_sc_hd__or2_1
X_7435_ clknet_leaf_48_clk net117 VGND VGND VPWR VPWR memory\[0\]\[28\] sky130_fd_sc_hd__dfxtp_1
X_7366_ clknet_leaf_38_clk _0925_ VGND VGND VPWR VPWR memory\[18\]\[23\] sky130_fd_sc_hd__dfxtp_1
Xhold720 memory\[9\]\[3\] VGND VGND VPWR VPWR net929 sky130_fd_sc_hd__dlygate4sd3_1
Xhold742 memory\[5\]\[24\] VGND VGND VPWR VPWR net951 sky130_fd_sc_hd__dlygate4sd3_1
Xhold764 memory\[7\]\[23\] VGND VGND VPWR VPWR net973 sky130_fd_sc_hd__dlygate4sd3_1
X_6317_ _2905_ _3183_ VGND VGND VPWR VPWR _3223_ sky130_fd_sc_hd__and2_1
X_4578_ _2224_ _2232_ VGND VGND VPWR VPWR _2233_ sky130_fd_sc_hd__and2_1
Xhold731 memory\[8\]\[0\] VGND VGND VPWR VPWR net940 sky130_fd_sc_hd__dlygate4sd3_1
Xhold753 memory\[22\]\[18\] VGND VGND VPWR VPWR net962 sky130_fd_sc_hd__dlygate4sd3_1
X_7297_ clknet_leaf_71_clk _0856_ VGND VGND VPWR VPWR memory\[8\]\[18\] sky130_fd_sc_hd__dfxtp_1
Xhold786 memory\[15\]\[5\] VGND VGND VPWR VPWR net995 sky130_fd_sc_hd__dlygate4sd3_1
Xhold775 memory\[22\]\[12\] VGND VGND VPWR VPWR net984 sky130_fd_sc_hd__dlygate4sd3_1
X_3529_ memory\[28\]\[2\] memory\[29\]\[2\] memory\[30\]\[2\] memory\[31\]\[2\] _1178_
+ _1179_ VGND VGND VPWR VPWR _1233_ sky130_fd_sc_hd__mux4_1
Xhold797 memory\[7\]\[18\] VGND VGND VPWR VPWR net1006 sky130_fd_sc_hd__dlygate4sd3_1
X_6248_ _2834_ _3184_ VGND VGND VPWR VPWR _3185_ sky130_fd_sc_hd__and2_1
X_6179_ net593 _3130_ _3138_ _3144_ VGND VGND VPWR VPWR _1129_ sky130_fd_sc_hd__a31o_1
XFILLER_0_98_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_237 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_94_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_35_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_120_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_117_37 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold91 memory\[21\]\[15\] VGND VGND VPWR VPWR net300 sky130_fd_sc_hd__dlygate4sd3_1
Xhold80 memory\[17\]\[9\] VGND VGND VPWR VPWR net289 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_26_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_73_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_73_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_70_clk clknet_4_13_0_clk VGND VGND VPWR VPWR clknet_leaf_70_clk sky130_fd_sc_hd__clkbuf_16
X_3880_ memory\[20\]\[19\] memory\[21\]\[19\] memory\[22\]\[19\] memory\[23\]\[19\]
+ _1509_ _1510_ VGND VGND VPWR VPWR _1567_ sky130_fd_sc_hd__mux4_1
XFILLER_0_45_207 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_26_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5481_ _2485_ _2772_ _2773_ net387 VGND VGND VPWR VPWR _0802_ sky130_fd_sc_hd__a22o_1
X_4501_ memory\[12\]\[15\] memory\[13\]\[15\] memory\[14\]\[15\] memory\[15\]\[15\]
+ _2045_ _2046_ VGND VGND VPWR VPWR _2160_ sky130_fd_sc_hd__mux4_1
XFILLER_0_26_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4432_ memory\[28\]\[12\] memory\[29\]\[12\] memory\[30\]\[12\] memory\[31\]\[12\]
+ _2092_ _2093_ VGND VGND VPWR VPWR _2094_ sky130_fd_sc_hd__mux4_1
X_7220_ clknet_leaf_4_clk _0811_ VGND VGND VPWR VPWR memory\[31\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_41_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4363_ _1799_ VGND VGND VPWR VPWR _2028_ sky130_fd_sc_hd__buf_8
X_7151_ clknet_leaf_102_clk _0742_ VGND VGND VPWR VPWR memory\[2\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_7082_ clknet_leaf_50_clk _0673_ VGND VGND VPWR VPWR memory\[4\]\[27\] sky130_fd_sc_hd__dfxtp_1
X_6102_ net655 _3088_ _3095_ _3100_ VGND VGND VPWR VPWR _1096_ sky130_fd_sc_hd__a31o_1
XTAP_332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4294_ memory\[24\]\[6\] memory\[25\]\[6\] memory\[26\]\[6\] memory\[27\]\[6\] _1960_
+ _1961_ VGND VGND VPWR VPWR _1962_ sky130_fd_sc_hd__mux4_1
XTAP_376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6033_ _2849_ _3053_ VGND VGND VPWR VPWR _3060_ sky130_fd_sc_hd__and2_1
XTAP_398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6935_ clknet_leaf_44_clk _0526_ VGND VGND VPWR VPWR memory\[10\]\[8\] sky130_fd_sc_hd__dfxtp_1
XPHY_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_119_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_61_clk clknet_4_15_0_clk VGND VGND VPWR VPWR clknet_leaf_61_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_76_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6866_ clknet_leaf_4_clk _0457_ VGND VGND VPWR VPWR memory\[28\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_119_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7429__123 VGND VGND VPWR VPWR _7429__123/HI net123 sky130_fd_sc_hd__conb_1
XFILLER_0_57_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6797_ _2619_ _3438_ _3440_ net440 VGND VGND VPWR VPWR _0426_ sky130_fd_sc_hd__a22o_1
X_5817_ _2463_ _2933_ _2935_ VGND VGND VPWR VPWR _0944_ sky130_fd_sc_hd__a21o_1
X_5748_ _2908_ VGND VGND VPWR VPWR _2909_ sky130_fd_sc_hd__buf_4
XFILLER_0_8_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_115_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_114_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5679_ net18 VGND VGND VPWR VPWR _2861_ sky130_fd_sc_hd__buf_4
XFILLER_0_114_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7418_ clknet_leaf_81_clk net134 VGND VGND VPWR VPWR memory\[0\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_13_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold550 memory\[30\]\[22\] VGND VGND VPWR VPWR net759 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_102_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7349_ clknet_leaf_114_clk _0908_ VGND VGND VPWR VPWR memory\[18\]\[6\] sky130_fd_sc_hd__dfxtp_1
Xhold561 memory\[4\]\[2\] VGND VGND VPWR VPWR net770 sky130_fd_sc_hd__dlygate4sd3_1
Xhold572 memory\[5\]\[8\] VGND VGND VPWR VPWR net781 sky130_fd_sc_hd__dlygate4sd3_1
Xhold583 memory\[16\]\[4\] VGND VGND VPWR VPWR net792 sky130_fd_sc_hd__dlygate4sd3_1
Xhold594 memory\[7\]\[2\] VGND VGND VPWR VPWR net803 sky130_fd_sc_hd__dlygate4sd3_1
X_7436__116 VGND VGND VPWR VPWR _7436__116/HI net116 sky130_fd_sc_hd__conb_1
XFILLER_0_99_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_99_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_leaf_52_clk clknet_4_14_0_clk VGND VGND VPWR VPWR clknet_leaf_52_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_55_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_12_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_2_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_120_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput70 net70 VGND VGND VPWR VPWR data_out1[28] sky130_fd_sc_hd__clkbuf_4
Xoutput92 net92 VGND VGND VPWR VPWR data_out2[19] sky130_fd_sc_hd__clkbuf_4
Xoutput81 net81 VGND VGND VPWR VPWR data_out1[9] sky130_fd_sc_hd__buf_2
XFILLER_0_37_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4981_ _2474_ _2525_ _2538_ VGND VGND VPWR VPWR _0537_ sky130_fd_sc_hd__a21o_1
XFILLER_0_53_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3932_ memory\[8\]\[21\] memory\[9\]\[21\] memory\[10\]\[21\] memory\[11\]\[21\]
+ _1202_ _1203_ VGND VGND VPWR VPWR _1617_ sky130_fd_sc_hd__mux4_1
X_6720_ _3385_ VGND VGND VPWR VPWR _3413_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_86_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_43_clk clknet_4_9_0_clk VGND VGND VPWR VPWR clknet_leaf_43_clk sky130_fd_sc_hd__clkbuf_16
X_5529__6 clknet_1_0__leaf__2784_ VGND VGND VPWR VPWR net151 sky130_fd_sc_hd__inv_2
X_6651_ _2640_ _3380_ _3381_ net719 VGND VGND VPWR VPWR _0339_ sky130_fd_sc_hd__a22o_1
X_3863_ _1187_ VGND VGND VPWR VPWR _1551_ sky130_fd_sc_hd__buf_8
X_6582_ net791 _3359_ _3351_ _3362_ VGND VGND VPWR VPWR _0289_ sky130_fd_sc_hd__a31o_1
X_5602_ _2730_ VGND VGND VPWR VPWR _2811_ sky130_fd_sc_hd__buf_4
XFILLER_0_61_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_624 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3794_ _1165_ VGND VGND VPWR VPWR _1486_ sky130_fd_sc_hd__buf_4
XFILLER_0_6_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5464_ _2468_ _2770_ _2771_ net511 VGND VGND VPWR VPWR _0787_ sky130_fd_sc_hd__a22o_1
XFILLER_0_41_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7203_ clknet_leaf_58_clk _0794_ VGND VGND VPWR VPWR memory\[14\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_111_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5395_ _2481_ _2754_ _2755_ net229 VGND VGND VPWR VPWR _0734_ sky130_fd_sc_hd__a22o_1
XFILLER_0_78_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4415_ memory\[0\]\[11\] memory\[1\]\[11\] memory\[2\]\[11\] memory\[3\]\[11\] _2017_
+ _2018_ VGND VGND VPWR VPWR _2078_ sky130_fd_sc_hd__mux4_1
XFILLER_0_111_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4346_ _2010_ _2011_ _1976_ VGND VGND VPWR VPWR _2012_ sky130_fd_sc_hd__mux2_1
X_7134_ clknet_leaf_83_clk _0725_ VGND VGND VPWR VPWR memory\[3\]\[15\] sky130_fd_sc_hd__dfxtp_1
X_6856__63 clknet_1_1__leaf__3446_ VGND VGND VPWR VPWR net208 sky130_fd_sc_hd__inv_2
XFILLER_0_94_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7065_ clknet_leaf_86_clk _0656_ VGND VGND VPWR VPWR memory\[4\]\[10\] sky130_fd_sc_hd__dfxtp_1
X_4277_ _1820_ _1945_ _1824_ VGND VGND VPWR VPWR _1946_ sky130_fd_sc_hd__o21a_1
X_6016_ net684 _3047_ _3007_ _3049_ VGND VGND VPWR VPWR _1061_ sky130_fd_sc_hd__a31o_1
XFILLER_0_96_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6918_ clknet_leaf_53_clk _0509_ VGND VGND VPWR VPWR memory\[15\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_119_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_34_clk clknet_4_11_0_clk VGND VGND VPWR VPWR clknet_leaf_34_clk sky130_fd_sc_hd__clkbuf_16
X_7898_ clknet_leaf_88_clk _0432_ VGND VGND VPWR VPWR memory\[17\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_37_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_9_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_119_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_92_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_103_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_102_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold380 memory\[18\]\[10\] VGND VGND VPWR VPWR net589 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_2_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold391 memory\[26\]\[23\] VGND VGND VPWR VPWR net600 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_68_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1851 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1840 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_114_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_25_clk clknet_4_8_0_clk VGND VGND VPWR VPWR clknet_leaf_25_clk sky130_fd_sc_hd__clkbuf_16
XTAP_1862 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_55_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4200_ _1832_ VGND VGND VPWR VPWR _1873_ sky130_fd_sc_hd__clkbuf_8
X_5180_ net34 VGND VGND VPWR VPWR _2667_ sky130_fd_sc_hd__buf_4
X_4131_ _1801_ VGND VGND VPWR VPWR _1805_ sky130_fd_sc_hd__buf_6
X_4062_ _1483_ _1739_ VGND VGND VPWR VPWR _1740_ sky130_fd_sc_hd__or2_1
X_7419__133 VGND VGND VPWR VPWR _7419__133/HI net133 sky130_fd_sc_hd__conb_1
XFILLER_0_3_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_7821_ clknet_leaf_49_clk _0355_ VGND VGND VPWR VPWR memory\[12\]\[30\] sky130_fd_sc_hd__dfxtp_1
X_7752_ clknet_leaf_24_clk _0286_ VGND VGND VPWR VPWR memory\[22\]\[25\] sky130_fd_sc_hd__dfxtp_1
X_4964_ _2507_ VGND VGND VPWR VPWR _2529_ sky130_fd_sc_hd__clkbuf_8
Xclkbuf_leaf_16_clk clknet_4_9_0_clk VGND VGND VPWR VPWR clknet_leaf_16_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_19_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3915_ _1599_ _1600_ _1521_ VGND VGND VPWR VPWR _1601_ sky130_fd_sc_hd__mux2_1
XFILLER_0_80_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6703_ net19 _3401_ VGND VGND VPWR VPWR _3404_ sky130_fd_sc_hd__and2_1
XFILLER_0_104_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7683_ clknet_leaf_18_clk _0217_ VGND VGND VPWR VPWR memory\[21\]\[20\] sky130_fd_sc_hd__dfxtp_1
X_4895_ _2460_ _2494_ _2496_ net679 VGND VGND VPWR VPWR _0492_ sky130_fd_sc_hd__a22o_1
XFILLER_0_58_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6634_ _3378_ VGND VGND VPWR VPWR _3379_ sky130_fd_sc_hd__buf_4
X_7426__126 VGND VGND VPWR VPWR _7426__126/HI net126 sky130_fd_sc_hd__conb_1
XFILLER_0_6_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3846_ _1397_ _1534_ _1401_ VGND VGND VPWR VPWR _1535_ sky130_fd_sc_hd__o21a_1
XFILLER_0_89_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6565_ net502 _3346_ _3351_ _3353_ VGND VGND VPWR VPWR _0281_ sky130_fd_sc_hd__a31o_1
XFILLER_0_61_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3777_ _1469_ VGND VGND VPWR VPWR _0004_ sky130_fd_sc_hd__clkbuf_1
X_5516_ _2659_ _2781_ _2782_ net755 VGND VGND VPWR VPWR _0828_ sky130_fd_sc_hd__a22o_1
X_6496_ _2891_ _3308_ VGND VGND VPWR VPWR _3313_ sky130_fd_sc_hd__and2_1
X_5447_ _2451_ _2766_ VGND VGND VPWR VPWR _2768_ sky130_fd_sc_hd__nor2_4
XFILLER_0_2_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5378_ _2750_ VGND VGND VPWR VPWR _2753_ sky130_fd_sc_hd__clkbuf_4
X_7117_ clknet_leaf_25_clk _0708_ VGND VGND VPWR VPWR memory\[29\]\[30\] sky130_fd_sc_hd__dfxtp_1
X_4329_ _1990_ _1992_ _1995_ _1978_ _1827_ VGND VGND VPWR VPWR _1996_ sky130_fd_sc_hd__a221o_1
X_7048_ clknet_leaf_32_clk _0639_ VGND VGND VPWR VPWR memory\[16\]\[25\] sky130_fd_sc_hd__dfxtp_1
X_7433__119 VGND VGND VPWR VPWR _7433__119/HI net119 sky130_fd_sc_hd__conb_1
XFILLER_0_96_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_108_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_65_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_165 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_9_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6859__2 clknet_1_1__leaf__2783_ VGND VGND VPWR VPWR net147 sky130_fd_sc_hd__inv_2
XFILLER_0_100_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_60_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_909 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6835__44 clknet_1_0__leaf__2787_ VGND VGND VPWR VPWR net189 sky130_fd_sc_hd__inv_2
XFILLER_0_88_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_430 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3700_ _1394_ _1395_ VGND VGND VPWR VPWR _1396_ sky130_fd_sc_hd__or2_1
X_4680_ _1811_ _2328_ VGND VGND VPWR VPWR _2329_ sky130_fd_sc_hd__or2_1
XFILLER_0_119_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3631_ _1330_ VGND VGND VPWR VPWR _0028_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_113_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6350_ _2659_ _3231_ _3232_ net1042 VGND VGND VPWR VPWR _0187_ sky130_fd_sc_hd__a22o_1
XFILLER_0_70_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3562_ _1155_ _1260_ _1262_ _1264_ _1184_ VGND VGND VPWR VPWR _1265_ sky130_fd_sc_hd__a221o_1
X_5301_ _2663_ _2721_ VGND VGND VPWR VPWR _2726_ sky130_fd_sc_hd__and2_1
XFILLER_0_12_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6281_ net1011 _3200_ _3196_ _3203_ VGND VGND VPWR VPWR _0147_ sky130_fd_sc_hd__a31o_1
X_3493_ _1156_ VGND VGND VPWR VPWR _1199_ sky130_fd_sc_hd__buf_6
XFILLER_0_121_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5232_ _2480_ _2688_ _2689_ net362 VGND VGND VPWR VPWR _0637_ sky130_fd_sc_hd__a22o_1
Xclkbuf_leaf_5_clk clknet_4_2_0_clk VGND VGND VPWR VPWR clknet_leaf_5_clk sky130_fd_sc_hd__clkbuf_16
X_5163_ _2654_ _2655_ VGND VGND VPWR VPWR _2656_ sky130_fd_sc_hd__and2_1
X_4114_ _1787_ _1788_ _1165_ VGND VGND VPWR VPWR _1789_ sky130_fd_sc_hd__mux2_1
X_5094_ net16 VGND VGND VPWR VPWR _2607_ sky130_fd_sc_hd__buf_4
X_4045_ memory\[0\]\[27\] memory\[1\]\[27\] memory\[2\]\[27\] memory\[3\]\[27\] _1271_
+ _1272_ VGND VGND VPWR VPWR _1724_ sky130_fd_sc_hd__mux4_2
XFILLER_0_78_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7804_ clknet_leaf_67_clk _0338_ VGND VGND VPWR VPWR memory\[12\]\[13\] sky130_fd_sc_hd__dfxtp_1
XPHY_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5996_ _2886_ _3036_ VGND VGND VPWR VPWR _3039_ sky130_fd_sc_hd__and2_1
XPHY_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_249 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4947_ _2457_ _2505_ _2519_ VGND VGND VPWR VPWR _0522_ sky130_fd_sc_hd__a21o_1
X_7735_ clknet_leaf_110_clk _0269_ VGND VGND VPWR VPWR memory\[22\]\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_117_532 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4878_ net40 VGND VGND VPWR VPWR _2488_ sky130_fd_sc_hd__buf_4
X_7666_ clknet_leaf_115_clk _0200_ VGND VGND VPWR VPWR memory\[21\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_6617_ _3369_ VGND VGND VPWR VPWR _3374_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_61_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3829_ memory\[4\]\[16\] memory\[5\]\[16\] memory\[6\]\[16\] memory\[7\]\[16\] _1360_
+ _1361_ VGND VGND VPWR VPWR _1519_ sky130_fd_sc_hd__mux4_1
X_7597_ clknet_leaf_21_clk _0131_ VGND VGND VPWR VPWR memory\[23\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_6_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6548_ net653 _3333_ _3338_ _3343_ VGND VGND VPWR VPWR _0274_ sky130_fd_sc_hd__a31o_1
XFILLER_0_15_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6479_ _2874_ _3295_ VGND VGND VPWR VPWR _3303_ sky130_fd_sc_hd__and2_1
XFILLER_0_69_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_706 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_84_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_65_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_7409__143 VGND VGND VPWR VPWR _7409__143/HI net143 sky130_fd_sc_hd__conb_1
XFILLER_0_111_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_108_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_21_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_103_292 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_103_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7416__136 VGND VGND VPWR VPWR _7416__136/HI net136 sky130_fd_sc_hd__conb_1
XFILLER_0_88_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5850_ _2482_ _2946_ _2953_ VGND VGND VPWR VPWR _0959_ sky130_fd_sc_hd__a21o_1
XFILLER_0_61_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_0__f__2785_ clknet_0__2785_ VGND VGND VPWR VPWR clknet_1_0__leaf__2785_
+ sky130_fd_sc_hd__clkbuf_16
X_5781_ _2665_ _2915_ _2916_ net842 VGND VGND VPWR VPWR _0927_ sky130_fd_sc_hd__a22o_1
X_4801_ net15 VGND VGND VPWR VPWR _2443_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_8_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4732_ _1978_ _2373_ _2375_ _2377_ _2223_ VGND VGND VPWR VPWR _2378_ sky130_fd_sc_hd__a221o_1
XFILLER_0_83_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7520_ clknet_leaf_70_clk _1079_ VGND VGND VPWR VPWR memory\[11\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_28_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4663_ _2311_ _2312_ _2191_ VGND VGND VPWR VPWR _2313_ sky130_fd_sc_hd__mux2_1
XFILLER_0_71_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7451_ clknet_leaf_82_clk _1010_ VGND VGND VPWR VPWR memory\[1\]\[12\] sky130_fd_sc_hd__dfxtp_1
X_3614_ memory\[20\]\[6\] memory\[21\]\[6\] memory\[22\]\[6\] memory\[23\]\[6\] _1312_
+ _1313_ VGND VGND VPWR VPWR _1314_ sky130_fd_sc_hd__mux4_1
X_6402_ net690 _3249_ _3250_ _3258_ VGND VGND VPWR VPWR _0213_ sky130_fd_sc_hd__a31o_1
X_4594_ _2104_ _2247_ _2106_ VGND VGND VPWR VPWR _2248_ sky130_fd_sc_hd__o21a_1
X_7423__129 VGND VGND VPWR VPWR _7423__129/HI net129 sky130_fd_sc_hd__conb_1
X_5562__36 clknet_1_1__leaf__2787_ VGND VGND VPWR VPWR net181 sky130_fd_sc_hd__inv_2
XFILLER_0_9_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7382_ clknet_leaf_9_clk _0941_ VGND VGND VPWR VPWR memory\[25\]\[7\] sky130_fd_sc_hd__dfxtp_1
Xhold902 memory\[25\]\[19\] VGND VGND VPWR VPWR net1111 sky130_fd_sc_hd__dlygate4sd3_1
Xhold913 memory\[25\]\[18\] VGND VGND VPWR VPWR net1122 sky130_fd_sc_hd__dlygate4sd3_1
Xhold946 memory\[25\]\[27\] VGND VGND VPWR VPWR net1155 sky130_fd_sc_hd__dlygate4sd3_1
Xhold935 memory\[6\]\[27\] VGND VGND VPWR VPWR net1144 sky130_fd_sc_hd__dlygate4sd3_1
X_6333_ _2627_ _3226_ _3228_ net651 VGND VGND VPWR VPWR _0174_ sky130_fd_sc_hd__a22o_1
XFILLER_0_12_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold924 memory\[25\]\[5\] VGND VGND VPWR VPWR net1133 sky130_fd_sc_hd__dlygate4sd3_1
X_3545_ _1245_ _1248_ VGND VGND VPWR VPWR _1249_ sky130_fd_sc_hd__or2_1
Xhold957 memory\[10\]\[4\] VGND VGND VPWR VPWR net1166 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_10_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6264_ net875 _3187_ _3182_ _3193_ VGND VGND VPWR VPWR _0140_ sky130_fd_sc_hd__a31o_1
X_3476_ _1177_ _1180_ _1181_ VGND VGND VPWR VPWR _1182_ sky130_fd_sc_hd__o21a_1
XFILLER_0_86_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5215_ _2682_ VGND VGND VPWR VPWR _2686_ sky130_fd_sc_hd__clkbuf_4
Xclkbuf_4_15_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_15_0_clk sky130_fd_sc_hd__clkbuf_8
X_6195_ _3139_ VGND VGND VPWR VPWR _3154_ sky130_fd_sc_hd__buf_2
XFILLER_0_43_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5146_ net1026 _2629_ _2630_ _2643_ VGND VGND VPWR VPWR _0597_ sky130_fd_sc_hd__a31o_1
X_5077_ _2484_ _2584_ _2594_ VGND VGND VPWR VPWR _0577_ sky130_fd_sc_hd__a21o_1
X_4028_ _1486_ _1707_ _1488_ VGND VGND VPWR VPWR _1708_ sky130_fd_sc_hd__o21a_1
XFILLER_0_79_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5979_ _2870_ _3023_ VGND VGND VPWR VPWR _3029_ sky130_fd_sc_hd__and2_1
X_7718_ clknet_leaf_64_clk _0252_ VGND VGND VPWR VPWR memory\[5\]\[23\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_74_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_35_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7649_ clknet_leaf_90_clk _0183_ VGND VGND VPWR VPWR memory\[19\]\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_34_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_105_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_122_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_108_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_111_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold209 memory\[19\]\[8\] VGND VGND VPWR VPWR net418 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_21_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5000_ _2484_ _2539_ _2549_ VGND VGND VPWR VPWR _0545_ sky130_fd_sc_hd__a21o_1
XTAP_536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6951_ clknet_leaf_51_clk _0542_ VGND VGND VPWR VPWR memory\[10\]\[24\] sky130_fd_sc_hd__dfxtp_1
X_6882_ clknet_leaf_35_clk _0473_ VGND VGND VPWR VPWR memory\[28\]\[20\] sky130_fd_sc_hd__dfxtp_1
X_5902_ net398 _2981_ _2977_ _2984_ VGND VGND VPWR VPWR _1012_ sky130_fd_sc_hd__a31o_1
XFILLER_0_48_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_119_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5833_ net1122 _2943_ _2934_ VGND VGND VPWR VPWR _2944_ sky130_fd_sc_hd__and3_1
XFILLER_0_48_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_463 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_56_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5764_ _2631_ _2913_ _2914_ net589 VGND VGND VPWR VPWR _0912_ sky130_fd_sc_hd__a22o_1
XFILLER_0_8_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7503_ clknet_leaf_11_clk _1062_ VGND VGND VPWR VPWR memory\[11\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_4715_ memory\[4\]\[27\] memory\[5\]\[27\] memory\[6\]\[27\] memory\[7\]\[27\] _1813_
+ _1815_ VGND VGND VPWR VPWR _2362_ sky130_fd_sc_hd__mux4_1
X_5695_ net23 VGND VGND VPWR VPWR _2872_ sky130_fd_sc_hd__clkbuf_4
X_4646_ memory\[8\]\[23\] memory\[9\]\[23\] memory\[10\]\[23\] memory\[11\]\[23\]
+ _1837_ _1838_ VGND VGND VPWR VPWR _2297_ sky130_fd_sc_hd__mux4_1
X_7434_ clknet_leaf_62_clk net118 VGND VGND VPWR VPWR memory\[0\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_4_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_44_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7365_ clknet_leaf_39_clk _0924_ VGND VGND VPWR VPWR memory\[18\]\[22\] sky130_fd_sc_hd__dfxtp_1
X_4577_ _2226_ _2228_ _2231_ _1797_ _2066_ VGND VGND VPWR VPWR _2232_ sky130_fd_sc_hd__a221o_1
Xhold721 memory\[21\]\[13\] VGND VGND VPWR VPWR net930 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_4_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold710 memory\[31\]\[5\] VGND VGND VPWR VPWR net919 sky130_fd_sc_hd__dlygate4sd3_1
Xhold754 memory\[13\]\[12\] VGND VGND VPWR VPWR net963 sky130_fd_sc_hd__dlygate4sd3_1
X_6316_ net1081 _3213_ _3181_ _3222_ VGND VGND VPWR VPWR _0163_ sky130_fd_sc_hd__a31o_1
Xhold743 memory\[8\]\[5\] VGND VGND VPWR VPWR net952 sky130_fd_sc_hd__dlygate4sd3_1
Xhold732 memory\[27\]\[17\] VGND VGND VPWR VPWR net941 sky130_fd_sc_hd__dlygate4sd3_1
Xhold787 memory\[18\]\[27\] VGND VGND VPWR VPWR net996 sky130_fd_sc_hd__dlygate4sd3_1
X_7296_ clknet_leaf_73_clk _0855_ VGND VGND VPWR VPWR memory\[8\]\[17\] sky130_fd_sc_hd__dfxtp_1
Xhold765 memory\[28\]\[6\] VGND VGND VPWR VPWR net974 sky130_fd_sc_hd__dlygate4sd3_1
Xhold776 memory\[22\]\[11\] VGND VGND VPWR VPWR net985 sky130_fd_sc_hd__dlygate4sd3_1
X_3528_ _1169_ _1231_ VGND VGND VPWR VPWR _1232_ sky130_fd_sc_hd__or2_1
Xhold798 memory\[7\]\[24\] VGND VGND VPWR VPWR net1007 sky130_fd_sc_hd__dlygate4sd3_1
X_3459_ _1164_ VGND VGND VPWR VPWR _1165_ sky130_fd_sc_hd__clkbuf_8
X_6247_ _3183_ VGND VGND VPWR VPWR _3184_ sky130_fd_sc_hd__buf_2
X_6178_ _2842_ _3140_ VGND VGND VPWR VPWR _3144_ sky130_fd_sc_hd__and2_1
XFILLER_0_99_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5129_ _2608_ VGND VGND VPWR VPWR _2632_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_79_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_249 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_94_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_591 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_35_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5541__17 clknet_1_1__leaf__2785_ VGND VGND VPWR VPWR net162 sky130_fd_sc_hd__inv_2
XFILLER_0_101_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold92 memory\[31\]\[23\] VGND VGND VPWR VPWR net301 sky130_fd_sc_hd__dlygate4sd3_1
Xhold81 memory\[12\]\[22\] VGND VGND VPWR VPWR net290 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_117_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold70 memory\[3\]\[27\] VGND VGND VPWR VPWR net279 sky130_fd_sc_hd__dlygate4sd3_1
X_7413__139 VGND VGND VPWR VPWR _7413__139/HI net139 sky130_fd_sc_hd__conb_1
XFILLER_0_85_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_13 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5480_ _2484_ _2772_ _2773_ net401 VGND VGND VPWR VPWR _0801_ sky130_fd_sc_hd__a22o_1
XFILLER_0_81_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4500_ _2101_ _2158_ VGND VGND VPWR VPWR _2159_ sky130_fd_sc_hd__or2_1
X_4431_ _1815_ VGND VGND VPWR VPWR _2093_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_101_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XANTENNA_1 _0046_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_672 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7150_ clknet_leaf_46_clk _0741_ VGND VGND VPWR VPWR memory\[3\]\[31\] sky130_fd_sc_hd__dfxtp_1
X_4362_ memory\[20\]\[9\] memory\[21\]\[9\] memory\[22\]\[9\] memory\[23\]\[9\] _1938_
+ _1939_ VGND VGND VPWR VPWR _2027_ sky130_fd_sc_hd__mux4_1
XFILLER_0_21_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7081_ clknet_leaf_48_clk _0672_ VGND VGND VPWR VPWR memory\[4\]\[26\] sky130_fd_sc_hd__dfxtp_1
X_4293_ _1832_ VGND VGND VPWR VPWR _1961_ sky130_fd_sc_hd__buf_6
X_6101_ _2840_ _3097_ VGND VGND VPWR VPWR _3100_ sky130_fd_sc_hd__and2_1
XTAP_333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6032_ net736 _3047_ _3051_ _3059_ VGND VGND VPWR VPWR _1067_ sky130_fd_sc_hd__a31o_1
XTAP_399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_119 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6934_ clknet_leaf_12_clk _0525_ VGND VGND VPWR VPWR memory\[10\]\[7\] sky130_fd_sc_hd__dfxtp_1
XPHY_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_119_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_633 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6865_ clknet_leaf_5_clk _0456_ VGND VGND VPWR VPWR memory\[28\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_49_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6796_ _2617_ _3438_ _3440_ net210 VGND VGND VPWR VPWR _0425_ sky130_fd_sc_hd__a22o_1
X_5816_ net1153 _2930_ _2934_ VGND VGND VPWR VPWR _2935_ sky130_fd_sc_hd__and3_1
XFILLER_0_36_219 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5747_ _2489_ _2501_ _2907_ VGND VGND VPWR VPWR _2908_ sky130_fd_sc_hd__and3_1
XFILLER_0_8_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_115_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5678_ net403 _2844_ _2857_ _2860_ VGND VGND VPWR VPWR _0880_ sky130_fd_sc_hd__a31o_1
X_7417_ clknet_leaf_81_clk net135 VGND VGND VPWR VPWR memory\[0\]\[10\] sky130_fd_sc_hd__dfxtp_1
X_4629_ memory\[4\]\[22\] memory\[5\]\[22\] memory\[6\]\[22\] memory\[7\]\[22\] _1842_
+ _1843_ VGND VGND VPWR VPWR _2281_ sky130_fd_sc_hd__mux4_1
Xhold551 memory\[7\]\[29\] VGND VGND VPWR VPWR net760 sky130_fd_sc_hd__dlygate4sd3_1
Xhold540 memory\[14\]\[14\] VGND VGND VPWR VPWR net749 sky130_fd_sc_hd__dlygate4sd3_1
X_7348_ clknet_leaf_116_clk _0907_ VGND VGND VPWR VPWR memory\[18\]\[5\] sky130_fd_sc_hd__dfxtp_1
Xhold562 memory\[3\]\[12\] VGND VGND VPWR VPWR net771 sky130_fd_sc_hd__dlygate4sd3_1
Xhold595 memory\[24\]\[29\] VGND VGND VPWR VPWR net804 sky130_fd_sc_hd__dlygate4sd3_1
X_7279_ clknet_leaf_20_clk _0838_ VGND VGND VPWR VPWR memory\[8\]\[0\] sky130_fd_sc_hd__dfxtp_1
Xhold584 memory\[1\]\[11\] VGND VGND VPWR VPWR net793 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold573 memory\[7\]\[16\] VGND VGND VPWR VPWR net782 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_99_469 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_67_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_67_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_12_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_106_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_121_633 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_31_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput60 net60 VGND VGND VPWR VPWR data_out1[19] sky130_fd_sc_hd__clkbuf_4
Xoutput93 net93 VGND VGND VPWR VPWR data_out2[1] sky130_fd_sc_hd__clkbuf_4
Xoutput82 net82 VGND VGND VPWR VPWR data_out2[0] sky130_fd_sc_hd__buf_2
Xoutput71 net71 VGND VGND VPWR VPWR data_out1[29] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_37_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4980_ net1109 _2530_ _2526_ VGND VGND VPWR VPWR _2538_ sky130_fd_sc_hd__and3_1
XFILLER_0_53_78 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3931_ _1584_ _1611_ _1613_ _1615_ _1597_ VGND VGND VPWR VPWR _1616_ sky130_fd_sc_hd__a221o_1
XFILLER_0_86_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6650_ _2638_ _3380_ _3381_ net658 VGND VGND VPWR VPWR _0338_ sky130_fd_sc_hd__a22o_1
XFILLER_0_73_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3862_ _1546_ _1549_ _1472_ VGND VGND VPWR VPWR _1550_ sky130_fd_sc_hd__mux2_1
X_6581_ _2899_ _3352_ VGND VGND VPWR VPWR _3362_ sky130_fd_sc_hd__and2_1
X_5601_ net854 _2798_ _2803_ _2810_ VGND VGND VPWR VPWR _0853_ sky130_fd_sc_hd__a31o_1
XFILLER_0_6_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3793_ _1483_ _1484_ VGND VGND VPWR VPWR _1485_ sky130_fd_sc_hd__or2_1
XFILLER_0_6_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_26_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5463_ _2467_ _2770_ _2771_ net610 VGND VGND VPWR VPWR _0786_ sky130_fd_sc_hd__a22o_1
XFILLER_0_41_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5394_ _2480_ _2754_ _2755_ net263 VGND VGND VPWR VPWR _0733_ sky130_fd_sc_hd__a22o_1
X_7202_ clknet_leaf_65_clk _0793_ VGND VGND VPWR VPWR memory\[14\]\[19\] sky130_fd_sc_hd__dfxtp_1
X_4414_ memory\[4\]\[11\] memory\[5\]\[11\] memory\[6\]\[11\] memory\[7\]\[11\] _2014_
+ _2015_ VGND VGND VPWR VPWR _2077_ sky130_fd_sc_hd__mux4_1
X_7133_ clknet_leaf_68_clk _0724_ VGND VGND VPWR VPWR memory\[3\]\[14\] sky130_fd_sc_hd__dfxtp_1
X_4345_ memory\[16\]\[8\] memory\[17\]\[8\] memory\[18\]\[8\] memory\[19\]\[8\] _1970_
+ _1971_ VGND VGND VPWR VPWR _2011_ sky130_fd_sc_hd__mux4_1
X_7064_ clknet_leaf_100_clk _0655_ VGND VGND VPWR VPWR memory\[4\]\[9\] sky130_fd_sc_hd__dfxtp_1
X_4276_ memory\[28\]\[5\] memory\[29\]\[5\] memory\[30\]\[5\] memory\[31\]\[5\] _1821_
+ _1822_ VGND VGND VPWR VPWR _1945_ sky130_fd_sc_hd__mux4_1
X_6015_ _2905_ _3009_ VGND VGND VPWR VPWR _3049_ sky130_fd_sc_hd__and2_1
XFILLER_0_118_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_631 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_49_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6917_ clknet_leaf_58_clk _0508_ VGND VGND VPWR VPWR memory\[15\]\[23\] sky130_fd_sc_hd__dfxtp_1
X_7897_ clknet_leaf_92_clk _0431_ VGND VGND VPWR VPWR memory\[17\]\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_91_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_92_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6779_ _2663_ _3434_ _3435_ net323 VGND VGND VPWR VPWR _0413_ sky130_fd_sc_hd__a22o_1
XFILLER_0_17_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold370 memory\[18\]\[16\] VGND VGND VPWR VPWR net579 sky130_fd_sc_hd__dlygate4sd3_1
Xhold381 memory\[8\]\[2\] VGND VGND VPWR VPWR net590 sky130_fd_sc_hd__dlygate4sd3_1
Xhold392 memory\[4\]\[11\] VGND VGND VPWR VPWR net601 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_99_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_99_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1852 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1841 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1830 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1863 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_36_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4130_ _1799_ VGND VGND VPWR VPWR _1804_ sky130_fd_sc_hd__buf_6
XFILLER_0_48_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4061_ memory\[8\]\[28\] memory\[9\]\[28\] memory\[10\]\[28\] memory\[11\]\[28\]
+ _1194_ _1195_ VGND VGND VPWR VPWR _1739_ sky130_fd_sc_hd__mux4_1
XFILLER_0_64_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5531__8 clknet_1_1__leaf__2784_ VGND VGND VPWR VPWR net153 sky130_fd_sc_hd__inv_2
XFILLER_0_3_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_7820_ clknet_leaf_52_clk _0354_ VGND VGND VPWR VPWR memory\[12\]\[29\] sky130_fd_sc_hd__dfxtp_1
X_7751_ clknet_leaf_27_clk _0285_ VGND VGND VPWR VPWR memory\[22\]\[24\] sky130_fd_sc_hd__dfxtp_1
X_4963_ _2466_ _2525_ _2528_ VGND VGND VPWR VPWR _0529_ sky130_fd_sc_hd__a21o_1
XFILLER_0_58_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3914_ memory\[0\]\[20\] memory\[1\]\[20\] memory\[2\]\[20\] memory\[3\]\[20\] _1363_
+ _1364_ VGND VGND VPWR VPWR _1600_ sky130_fd_sc_hd__mux4_1
X_6702_ net439 _3393_ _3400_ _3403_ VGND VGND VPWR VPWR _0368_ sky130_fd_sc_hd__a31o_1
X_7682_ clknet_leaf_108_clk _0216_ VGND VGND VPWR VPWR memory\[21\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_46_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_104_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6633_ _2450_ _3376_ VGND VGND VPWR VPWR _3378_ sky130_fd_sc_hd__nor2_4
XFILLER_0_80_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4894_ _2459_ _2494_ _2496_ net906 VGND VGND VPWR VPWR _0491_ sky130_fd_sc_hd__a22o_1
XFILLER_0_116_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3845_ memory\[28\]\[17\] memory\[29\]\[17\] memory\[30\]\[17\] memory\[31\]\[17\]
+ _1398_ _1399_ VGND VGND VPWR VPWR _1534_ sky130_fd_sc_hd__mux4_1
X_6564_ _2881_ _3352_ VGND VGND VPWR VPWR _3353_ sky130_fd_sc_hd__and2_1
XFILLER_0_14_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3776_ _1460_ _1468_ VGND VGND VPWR VPWR _1469_ sky130_fd_sc_hd__and2_1
X_5515_ _2657_ _2781_ _2782_ net272 VGND VGND VPWR VPWR _0827_ sky130_fd_sc_hd__a22o_1
X_6495_ net582 _3304_ _3307_ _3312_ VGND VGND VPWR VPWR _0252_ sky130_fd_sc_hd__a31o_1
XFILLER_0_89_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5446_ _2766_ VGND VGND VPWR VPWR _2767_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_73_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_42_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_112_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_100_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5377_ _2748_ VGND VGND VPWR VPWR _2752_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_1_193 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_7116_ clknet_leaf_35_clk _0707_ VGND VGND VPWR VPWR memory\[29\]\[29\] sky130_fd_sc_hd__dfxtp_1
X_4328_ _1993_ _1994_ _1976_ VGND VGND VPWR VPWR _1995_ sky130_fd_sc_hd__mux2_1
X_7047_ clknet_leaf_32_clk _0638_ VGND VGND VPWR VPWR memory\[16\]\[24\] sky130_fd_sc_hd__dfxtp_1
X_4259_ memory\[4\]\[4\] memory\[5\]\[4\] memory\[6\]\[4\] memory\[7\]\[4\] _1863_
+ _1864_ VGND VGND VPWR VPWR _1929_ sky130_fd_sc_hd__mux4_1
XTAP_1104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7949_ net148 _0055_ VGND VGND VPWR VPWR net73 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_77_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_108_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_92_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_177 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_52_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_107_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_109_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_87_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3630_ _1321_ _1329_ VGND VGND VPWR VPWR _1330_ sky130_fd_sc_hd__and2_1
XFILLER_0_3_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3561_ _1177_ _1263_ _1181_ VGND VGND VPWR VPWR _1264_ sky130_fd_sc_hd__o21a_1
XFILLER_0_113_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5300_ net374 _2717_ _2720_ _2725_ VGND VGND VPWR VPWR _0669_ sky130_fd_sc_hd__a31o_1
XFILLER_0_11_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_121_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3492_ _1193_ _1196_ _1197_ VGND VGND VPWR VPWR _1198_ sky130_fd_sc_hd__o21a_1
X_6280_ _2868_ _3197_ VGND VGND VPWR VPWR _3203_ sky130_fd_sc_hd__and2_1
X_5231_ _2479_ _2688_ _2689_ net650 VGND VGND VPWR VPWR _0636_ sky130_fd_sc_hd__a22o_1
X_5162_ _2608_ VGND VGND VPWR VPWR _2655_ sky130_fd_sc_hd__buf_2
XFILLER_0_75_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4113_ memory\[0\]\[31\] memory\[1\]\[31\] memory\[2\]\[31\] memory\[3\]\[31\] _1237_
+ _1238_ VGND VGND VPWR VPWR _1788_ sky130_fd_sc_hd__mux4_1
X_5093_ _2605_ VGND VGND VPWR VPWR _2606_ sky130_fd_sc_hd__clkbuf_4
X_4044_ memory\[4\]\[27\] memory\[5\]\[27\] memory\[6\]\[27\] memory\[7\]\[27\] _1161_
+ _1162_ VGND VGND VPWR VPWR _1723_ sky130_fd_sc_hd__mux4_1
XFILLER_0_79_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7432__120 VGND VGND VPWR VPWR _7432__120/HI net120 sky130_fd_sc_hd__conb_1
X_7803_ clknet_leaf_71_clk _0337_ VGND VGND VPWR VPWR memory\[12\]\[12\] sky130_fd_sc_hd__dfxtp_1
XPHY_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5995_ net1092 _3034_ _3035_ _3038_ VGND VGND VPWR VPWR _1051_ sky130_fd_sc_hd__a31o_1
X_7734_ clknet_leaf_110_clk _0268_ VGND VGND VPWR VPWR memory\[22\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_74_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4946_ net1166 _2516_ _2513_ VGND VGND VPWR VPWR _2519_ sky130_fd_sc_hd__and3_1
XFILLER_0_117_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4877_ _2487_ _2448_ _2452_ net1091 VGND VGND VPWR VPWR _0483_ sky130_fd_sc_hd__a22o_1
X_7665_ clknet_leaf_115_clk _0199_ VGND VGND VPWR VPWR memory\[21\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_6616_ _3367_ VGND VGND VPWR VPWR _3373_ sky130_fd_sc_hd__clkbuf_4
X_7596_ clknet_leaf_24_clk _0130_ VGND VGND VPWR VPWR memory\[23\]\[29\] sky130_fd_sc_hd__dfxtp_1
X_3828_ _1390_ _1513_ _1515_ _1517_ _1403_ VGND VGND VPWR VPWR _1518_ sky130_fd_sc_hd__a221o_1
XFILLER_0_61_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6547_ _2865_ _3339_ VGND VGND VPWR VPWR _3343_ sky130_fd_sc_hd__and2_1
X_3759_ _1452_ VGND VGND VPWR VPWR _0003_ sky130_fd_sc_hd__clkbuf_1
X_6478_ net1059 _3291_ _3294_ _3302_ VGND VGND VPWR VPWR _0245_ sky130_fd_sc_hd__a31o_1
X_5429_ _2474_ _2761_ _2762_ net251 VGND VGND VPWR VPWR _0761_ sky130_fd_sc_hd__a22o_1
XFILLER_0_100_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6861__4 clknet_1_1__leaf__2783_ VGND VGND VPWR VPWR net149 sky130_fd_sc_hd__inv_2
XFILLER_0_84_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_111_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_80_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_0__f__2784_ clknet_0__2784_ VGND VGND VPWR VPWR clknet_1_0__leaf__2784_
+ sky130_fd_sc_hd__clkbuf_16
X_4800_ net48 net49 set\[0\] VGND VGND VPWR VPWR _2442_ sky130_fd_sc_hd__and3b_2
X_5780_ _2663_ _2915_ _2916_ net662 VGND VGND VPWR VPWR _0926_ sky130_fd_sc_hd__a22o_1
XFILLER_0_56_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_209 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4731_ _1876_ _2376_ _1880_ VGND VGND VPWR VPWR _2377_ sky130_fd_sc_hd__o21a_1
XFILLER_0_29_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4662_ memory\[0\]\[24\] memory\[1\]\[24\] memory\[2\]\[24\] memory\[3\]\[24\] _1863_
+ _1864_ VGND VGND VPWR VPWR _2312_ sky130_fd_sc_hd__mux4_1
X_5547__23 clknet_1_0__leaf__2785_ VGND VGND VPWR VPWR net168 sky130_fd_sc_hd__inv_2
X_7450_ clknet_leaf_81_clk _1009_ VGND VGND VPWR VPWR memory\[1\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_4_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3613_ _1158_ VGND VGND VPWR VPWR _1313_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_9_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6401_ _2872_ _3251_ VGND VGND VPWR VPWR _3258_ sky130_fd_sc_hd__and2_1
X_4593_ memory\[12\]\[20\] memory\[13\]\[20\] memory\[14\]\[20\] memory\[15\]\[20\]
+ _2045_ _2046_ VGND VGND VPWR VPWR _2247_ sky130_fd_sc_hd__mux4_1
Xhold903 memory\[10\]\[21\] VGND VGND VPWR VPWR net1112 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_71_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7381_ clknet_leaf_2_clk _0940_ VGND VGND VPWR VPWR memory\[25\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_43_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold936 memory\[25\]\[24\] VGND VGND VPWR VPWR net1145 sky130_fd_sc_hd__dlygate4sd3_1
Xhold914 memory\[6\]\[28\] VGND VGND VPWR VPWR net1123 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6332_ _2625_ _3226_ _3228_ net418 VGND VGND VPWR VPWR _0173_ sky130_fd_sc_hd__a22o_1
Xhold925 memory\[25\]\[8\] VGND VGND VPWR VPWR net1134 sky130_fd_sc_hd__dlygate4sd3_1
X_3544_ memory\[8\]\[2\] memory\[9\]\[2\] memory\[10\]\[2\] memory\[11\]\[2\] _1246_
+ _1247_ VGND VGND VPWR VPWR _1248_ sky130_fd_sc_hd__mux4_1
Xhold958 memory\[10\]\[24\] VGND VGND VPWR VPWR net1167 sky130_fd_sc_hd__dlygate4sd3_1
Xhold947 memory\[10\]\[16\] VGND VGND VPWR VPWR net1156 sky130_fd_sc_hd__dlygate4sd3_1
X_6263_ _2851_ _3184_ VGND VGND VPWR VPWR _3193_ sky130_fd_sc_hd__and2_1
X_3475_ _1153_ VGND VGND VPWR VPWR _1181_ sky130_fd_sc_hd__clkbuf_4
X_5214_ _2462_ _2683_ _2685_ net888 VGND VGND VPWR VPWR _0623_ sky130_fd_sc_hd__a22o_1
X_6194_ _3137_ VGND VGND VPWR VPWR _3153_ sky130_fd_sc_hd__clkbuf_4
X_5145_ _2642_ _2632_ VGND VGND VPWR VPWR _2643_ sky130_fd_sc_hd__and2_1
XFILLER_0_36_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5076_ net1144 _2585_ _2586_ VGND VGND VPWR VPWR _2594_ sky130_fd_sc_hd__and3_1
XFILLER_0_98_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4027_ memory\[12\]\[26\] memory\[13\]\[26\] memory\[14\]\[26\] memory\[15\]\[26\]
+ _1246_ _1247_ VGND VGND VPWR VPWR _1707_ sky130_fd_sc_hd__mux4_1
XFILLER_0_67_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5978_ net497 _3021_ _3022_ _3028_ VGND VGND VPWR VPWR _1044_ sky130_fd_sc_hd__a31o_1
X_7717_ clknet_leaf_66_clk _0251_ VGND VGND VPWR VPWR memory\[5\]\[22\] sky130_fd_sc_hd__dfxtp_1
X_4929_ set\[0\] _0517_ VGND VGND VPWR VPWR _2506_ sky130_fd_sc_hd__and2_1
XFILLER_0_74_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7648_ clknet_leaf_90_clk _0182_ VGND VGND VPWR VPWR memory\[19\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_62_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7579_ clknet_leaf_94_clk _1138_ VGND VGND VPWR VPWR memory\[23\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_50_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_106_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_97_353 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_97_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_38 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_85_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_710 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_25_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_108_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7422__130 VGND VGND VPWR VPWR _7422__130/HI net130 sky130_fd_sc_hd__conb_1
XFILLER_0_0_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6950_ clknet_leaf_54_clk _0541_ VGND VGND VPWR VPWR memory\[10\]\[23\] sky130_fd_sc_hd__dfxtp_1
X_5901_ _2868_ _2978_ VGND VGND VPWR VPWR _2984_ sky130_fd_sc_hd__and2_1
X_6881_ clknet_leaf_79_clk _0472_ VGND VGND VPWR VPWR memory\[28\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_49_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5832_ _2529_ VGND VGND VPWR VPWR _2943_ sky130_fd_sc_hd__buf_4
XFILLER_0_8_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_604 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5763_ _2911_ VGND VGND VPWR VPWR _2914_ sky130_fd_sc_hd__clkbuf_4
X_4714_ _1978_ _2356_ _2358_ _2360_ _2223_ VGND VGND VPWR VPWR _2361_ sky130_fd_sc_hd__a221o_1
X_7502_ clknet_leaf_19_clk _1061_ VGND VGND VPWR VPWR memory\[24\]\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_29_475 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5694_ net604 _2867_ _2857_ _2871_ VGND VGND VPWR VPWR _0885_ sky130_fd_sc_hd__a31o_1
X_7433_ clknet_leaf_60_clk net119 VGND VGND VPWR VPWR memory\[0\]\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_112_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4645_ _2294_ _2295_ _2191_ VGND VGND VPWR VPWR _2296_ sky130_fd_sc_hd__mux2_1
XFILLER_0_4_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold711 memory\[18\]\[21\] VGND VGND VPWR VPWR net920 sky130_fd_sc_hd__dlygate4sd3_1
X_7364_ clknet_leaf_39_clk _0923_ VGND VGND VPWR VPWR memory\[18\]\[21\] sky130_fd_sc_hd__dfxtp_1
X_4576_ _2229_ _2230_ _1809_ VGND VGND VPWR VPWR _2231_ sky130_fd_sc_hd__mux2_1
XFILLER_0_71_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_553 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold700 memory\[23\]\[18\] VGND VGND VPWR VPWR net909 sky130_fd_sc_hd__dlygate4sd3_1
Xhold733 memory\[24\]\[24\] VGND VGND VPWR VPWR net942 sky130_fd_sc_hd__dlygate4sd3_1
X_6315_ _2903_ _3183_ VGND VGND VPWR VPWR _3222_ sky130_fd_sc_hd__and2_1
Xhold755 memory\[18\]\[5\] VGND VGND VPWR VPWR net964 sky130_fd_sc_hd__dlygate4sd3_1
Xhold744 memory\[27\]\[16\] VGND VGND VPWR VPWR net953 sky130_fd_sc_hd__dlygate4sd3_1
X_3527_ memory\[24\]\[2\] memory\[25\]\[2\] memory\[26\]\[2\] memory\[27\]\[2\] _1171_
+ _1173_ VGND VGND VPWR VPWR _1231_ sky130_fd_sc_hd__mux4_1
Xhold722 memory\[11\]\[4\] VGND VGND VPWR VPWR net931 sky130_fd_sc_hd__dlygate4sd3_1
Xhold788 memory\[27\]\[21\] VGND VGND VPWR VPWR net997 sky130_fd_sc_hd__dlygate4sd3_1
Xhold777 memory\[8\]\[6\] VGND VGND VPWR VPWR net986 sky130_fd_sc_hd__dlygate4sd3_1
X_7295_ clknet_leaf_69_clk _0854_ VGND VGND VPWR VPWR memory\[8\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_12_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold766 memory\[20\]\[3\] VGND VGND VPWR VPWR net975 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_110_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold799 memory\[1\]\[21\] VGND VGND VPWR VPWR net1008 sky130_fd_sc_hd__dlygate4sd3_1
X_3458_ net8 VGND VGND VPWR VPWR _1164_ sky130_fd_sc_hd__inv_2
X_6246_ _2510_ _2490_ _2603_ VGND VGND VPWR VPWR _3183_ sky130_fd_sc_hd__and3_4
X_6177_ net554 _3130_ _3138_ _3143_ VGND VGND VPWR VPWR _1128_ sky130_fd_sc_hd__a31o_1
X_5128_ net17 VGND VGND VPWR VPWR _2631_ sky130_fd_sc_hd__buf_4
X_5059_ _2555_ VGND VGND VPWR VPWR _2584_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_79_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_50_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold71 memory\[13\]\[18\] VGND VGND VPWR VPWR net280 sky130_fd_sc_hd__dlygate4sd3_1
Xhold82 memory\[14\]\[3\] VGND VGND VPWR VPWR net291 sky130_fd_sc_hd__dlygate4sd3_1
Xhold60 memory\[28\]\[11\] VGND VGND VPWR VPWR net269 sky130_fd_sc_hd__dlygate4sd3_1
Xhold93 memory\[13\]\[2\] VGND VGND VPWR VPWR net302 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_42_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_4_14_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_14_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_81_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_111_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4430_ _1813_ VGND VGND VPWR VPWR _2092_ sky130_fd_sc_hd__buf_6
XANTENNA_2 _1154_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4361_ _2026_ VGND VGND VPWR VPWR _0062_ sky130_fd_sc_hd__buf_1
X_6100_ net517 _3088_ _3095_ _3099_ VGND VGND VPWR VPWR _1095_ sky130_fd_sc_hd__a31o_1
X_7080_ clknet_leaf_56_clk _0671_ VGND VGND VPWR VPWR memory\[4\]\[25\] sky130_fd_sc_hd__dfxtp_1
X_4292_ _1830_ VGND VGND VPWR VPWR _1960_ sky130_fd_sc_hd__buf_8
XTAP_323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6031_ _2847_ _3053_ VGND VGND VPWR VPWR _3059_ sky130_fd_sc_hd__and2_1
XTAP_389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6933_ clknet_leaf_14_clk _0524_ VGND VGND VPWR VPWR memory\[10\]\[6\] sky130_fd_sc_hd__dfxtp_1
XPHY_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6864_ clknet_leaf_3_clk _0455_ VGND VGND VPWR VPWR memory\[28\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_5815_ _2920_ VGND VGND VPWR VPWR _2934_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_91_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6795_ _2615_ _3438_ _3440_ net212 VGND VGND VPWR VPWR _0424_ sky130_fd_sc_hd__a22o_1
X_5746_ _2444_ _2445_ _2443_ VGND VGND VPWR VPWR _2907_ sky130_fd_sc_hd__nor3b_1
XFILLER_0_17_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5677_ _2858_ _2859_ VGND VGND VPWR VPWR _2860_ sky130_fd_sc_hd__and2_1
XFILLER_0_114_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4628_ _1976_ _2279_ _1796_ VGND VGND VPWR VPWR _2280_ sky130_fd_sc_hd__o21a_1
XFILLER_0_72_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7416_ clknet_leaf_11_clk net136 VGND VGND VPWR VPWR memory\[0\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_115_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold530 memory\[11\]\[28\] VGND VGND VPWR VPWR net739 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_102_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_102_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4559_ _2206_ _2214_ VGND VGND VPWR VPWR _2215_ sky130_fd_sc_hd__and2_1
XFILLER_0_13_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_7347_ clknet_leaf_116_clk _0906_ VGND VGND VPWR VPWR memory\[18\]\[4\] sky130_fd_sc_hd__dfxtp_1
Xhold552 memory\[18\]\[3\] VGND VGND VPWR VPWR net761 sky130_fd_sc_hd__dlygate4sd3_1
Xhold563 memory\[31\]\[4\] VGND VGND VPWR VPWR net772 sky130_fd_sc_hd__dlygate4sd3_1
Xhold541 memory\[1\]\[0\] VGND VGND VPWR VPWR net750 sky130_fd_sc_hd__dlygate4sd3_1
Xhold585 memory\[8\]\[23\] VGND VGND VPWR VPWR net794 sky130_fd_sc_hd__dlygate4sd3_1
Xhold574 memory\[9\]\[28\] VGND VGND VPWR VPWR net783 sky130_fd_sc_hd__dlygate4sd3_1
X_7278_ net181 _0024_ VGND VGND VPWR VPWR net106 sky130_fd_sc_hd__dfxtp_1
Xhold596 memory\[28\]\[16\] VGND VGND VPWR VPWR net805 sky130_fd_sc_hd__dlygate4sd3_1
X_6229_ net815 _3172_ _3166_ _3173_ VGND VGND VPWR VPWR _1150_ sky130_fd_sc_hd__a31o_1
XTAP_890 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7412__140 VGND VGND VPWR VPWR _7412__140/HI net140 sky130_fd_sc_hd__conb_1
XFILLER_0_95_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_105_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_121_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput50 net50 VGND VGND VPWR VPWR data_out1[0] sky130_fd_sc_hd__clkbuf_4
Xoutput61 net61 VGND VGND VPWR VPWR data_out1[1] sky130_fd_sc_hd__clkbuf_4
Xoutput94 net94 VGND VGND VPWR VPWR data_out2[20] sky130_fd_sc_hd__clkbuf_4
Xoutput72 net72 VGND VGND VPWR VPWR data_out1[2] sky130_fd_sc_hd__clkbuf_4
Xoutput83 net83 VGND VGND VPWR VPWR data_out2[10] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_77_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3930_ _1591_ _1614_ _1595_ VGND VGND VPWR VPWR _1615_ sky130_fd_sc_hd__o21a_1
XFILLER_0_85_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3861_ memory\[16\]\[18\] memory\[17\]\[18\] memory\[18\]\[18\] memory\[19\]\[18\]
+ _1547_ _1548_ VGND VGND VPWR VPWR _1549_ sky130_fd_sc_hd__mux4_1
X_6580_ net798 _3359_ _3351_ _3361_ VGND VGND VPWR VPWR _0288_ sky130_fd_sc_hd__a31o_1
XFILLER_0_73_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3792_ memory\[8\]\[14\] memory\[9\]\[14\] memory\[10\]\[14\] memory\[11\]\[14\]
+ _1426_ _1427_ VGND VGND VPWR VPWR _1484_ sky130_fd_sc_hd__mux4_1
X_5600_ _2642_ _2804_ VGND VGND VPWR VPWR _2810_ sky130_fd_sc_hd__and2_1
XFILLER_0_54_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7201_ clknet_leaf_71_clk _0792_ VGND VGND VPWR VPWR memory\[14\]\[18\] sky130_fd_sc_hd__dfxtp_1
X_5462_ _2466_ _2770_ _2771_ net811 VGND VGND VPWR VPWR _0785_ sky130_fd_sc_hd__a22o_1
XFILLER_0_112_656 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_112_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5393_ _2479_ _2754_ _2755_ net663 VGND VGND VPWR VPWR _0732_ sky130_fd_sc_hd__a22o_1
X_4413_ _2070_ _2072_ _2075_ _1978_ _2038_ VGND VGND VPWR VPWR _2076_ sky130_fd_sc_hd__a221o_1
X_4344_ memory\[20\]\[8\] memory\[21\]\[8\] memory\[22\]\[8\] memory\[23\]\[8\] _1831_
+ _1833_ VGND VGND VPWR VPWR _2010_ sky130_fd_sc_hd__mux4_1
X_7132_ clknet_leaf_82_clk _0723_ VGND VGND VPWR VPWR memory\[3\]\[13\] sky130_fd_sc_hd__dfxtp_1
X_7063_ clknet_leaf_99_clk _0654_ VGND VGND VPWR VPWR memory\[4\]\[8\] sky130_fd_sc_hd__dfxtp_1
X_6014_ net708 _3047_ _3007_ _3048_ VGND VGND VPWR VPWR _1060_ sky130_fd_sc_hd__a31o_1
X_4275_ _1812_ _1943_ VGND VGND VPWR VPWR _1944_ sky130_fd_sc_hd__or2_1
XFILLER_0_96_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_68_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6916_ clknet_leaf_58_clk _0507_ VGND VGND VPWR VPWR memory\[15\]\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_77_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7896_ clknet_leaf_106_clk _0430_ VGND VGND VPWR VPWR memory\[17\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_92_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6847_ clknet_1_1__leaf__2783_ VGND VGND VPWR VPWR _3446_ sky130_fd_sc_hd__buf_1
XFILLER_0_37_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6778_ _2661_ _3434_ _3435_ net235 VGND VGND VPWR VPWR _0412_ sky130_fd_sc_hd__a22o_1
XFILLER_0_76_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5729_ _2895_ _2882_ VGND VGND VPWR VPWR _2896_ sky130_fd_sc_hd__and2_1
XFILLER_0_91_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_leaf_111_clk clknet_4_1_0_clk VGND VGND VPWR VPWR clknet_leaf_111_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_13_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold371 memory\[28\]\[25\] VGND VGND VPWR VPWR net580 sky130_fd_sc_hd__dlygate4sd3_1
Xhold360 memory\[23\]\[21\] VGND VGND VPWR VPWR net569 sky130_fd_sc_hd__dlygate4sd3_1
Xhold393 memory\[2\]\[29\] VGND VGND VPWR VPWR net602 sky130_fd_sc_hd__dlygate4sd3_1
Xhold382 memory\[31\]\[7\] VGND VGND VPWR VPWR net591 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_99_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1842 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1831 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1820 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_114_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_95_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1864 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1853 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_315 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_28_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_113_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_2_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_102_clk clknet_4_3_0_clk VGND VGND VPWR VPWR clknet_leaf_102_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_11_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4060_ _1736_ _1737_ _1521_ VGND VGND VPWR VPWR _1738_ sky130_fd_sc_hd__mux2_1
XFILLER_0_3_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_64_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7750_ clknet_leaf_18_clk _0284_ VGND VGND VPWR VPWR memory\[22\]\[23\] sky130_fd_sc_hd__dfxtp_1
X_4962_ memory\[10\]\[11\] _2516_ _2526_ VGND VGND VPWR VPWR _2528_ sky130_fd_sc_hd__and3_1
X_3913_ memory\[4\]\[20\] memory\[5\]\[20\] memory\[6\]\[20\] memory\[7\]\[20\] _1360_
+ _1361_ VGND VGND VPWR VPWR _1599_ sky130_fd_sc_hd__mux4_1
XFILLER_0_86_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6701_ net18 _3401_ VGND VGND VPWR VPWR _3403_ sky130_fd_sc_hd__and2_1
X_4893_ _2458_ _2494_ _2496_ net995 VGND VGND VPWR VPWR _0490_ sky130_fd_sc_hd__a22o_1
X_7681_ clknet_leaf_94_clk _0215_ VGND VGND VPWR VPWR memory\[21\]\[18\] sky130_fd_sc_hd__dfxtp_1
X_6632_ _3376_ VGND VGND VPWR VPWR _3377_ sky130_fd_sc_hd__buf_4
X_3844_ _1394_ _1532_ VGND VGND VPWR VPWR _1533_ sky130_fd_sc_hd__or2_1
XFILLER_0_73_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6563_ _3325_ VGND VGND VPWR VPWR _3352_ sky130_fd_sc_hd__buf_2
X_3775_ _1236_ _1463_ _1465_ _1467_ _1412_ VGND VGND VPWR VPWR _1468_ sky130_fd_sc_hd__a221o_1
X_5514_ _2654_ _2781_ _2782_ net481 VGND VGND VPWR VPWR _0826_ sky130_fd_sc_hd__a22o_1
X_6494_ _2888_ _3308_ VGND VGND VPWR VPWR _3312_ sky130_fd_sc_hd__and2_1
XFILLER_0_120_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5445_ _2765_ VGND VGND VPWR VPWR _2766_ sky130_fd_sc_hd__clkbuf_4
X_7115_ clknet_leaf_35_clk _0706_ VGND VGND VPWR VPWR memory\[29\]\[28\] sky130_fd_sc_hd__dfxtp_1
X_5376_ _2462_ _2749_ _2751_ net442 VGND VGND VPWR VPWR _0719_ sky130_fd_sc_hd__a22o_1
X_4327_ memory\[16\]\[7\] memory\[17\]\[7\] memory\[18\]\[7\] memory\[19\]\[7\] _1970_
+ _1971_ VGND VGND VPWR VPWR _1994_ sky130_fd_sc_hd__mux4_1
X_7046_ clknet_leaf_38_clk _0637_ VGND VGND VPWR VPWR memory\[16\]\[23\] sky130_fd_sc_hd__dfxtp_1
X_4258_ _1798_ _1923_ _1925_ _1927_ _1827_ VGND VGND VPWR VPWR _1928_ sky130_fd_sc_hd__a221o_1
X_4189_ _1797_ VGND VGND VPWR VPWR _1862_ sky130_fd_sc_hd__buf_4
XFILLER_0_97_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7948_ net147 _0053_ VGND VGND VPWR VPWR net71 sky130_fd_sc_hd__dfxtp_2
XFILLER_0_49_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7879_ clknet_leaf_53_clk _0413_ VGND VGND VPWR VPWR memory\[13\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_92_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_92_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_122_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold190 memory\[2\]\[15\] VGND VGND VPWR VPWR net399 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_18_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_95_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_126 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_36_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_70_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3560_ memory\[28\]\[3\] memory\[29\]\[3\] memory\[30\]\[3\] memory\[31\]\[3\] _1178_
+ _1179_ VGND VGND VPWR VPWR _1263_ sky130_fd_sc_hd__mux4_1
X_5230_ _2478_ _2688_ _2689_ net444 VGND VGND VPWR VPWR _0635_ sky130_fd_sc_hd__a22o_1
X_3491_ net9 VGND VGND VPWR VPWR _1197_ sky130_fd_sc_hd__buf_4
XFILLER_0_11_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5161_ net28 VGND VGND VPWR VPWR _2654_ sky130_fd_sc_hd__buf_4
XFILLER_0_52_9 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4112_ memory\[4\]\[31\] memory\[5\]\[31\] memory\[6\]\[31\] memory\[7\]\[31\] _1170_
+ _1172_ VGND VGND VPWR VPWR _1787_ sky130_fd_sc_hd__mux4_1
X_5092_ _2604_ VGND VGND VPWR VPWR _2605_ sky130_fd_sc_hd__clkbuf_4
X_4043_ _1205_ _1721_ _1153_ VGND VGND VPWR VPWR _1722_ sky130_fd_sc_hd__o21a_1
XFILLER_0_75_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6841__49 clknet_1_0__leaf__3445_ VGND VGND VPWR VPWR net194 sky130_fd_sc_hd__inv_2
X_5994_ _2884_ _3036_ VGND VGND VPWR VPWR _3038_ sky130_fd_sc_hd__and2_1
XFILLER_0_91_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7802_ clknet_leaf_69_clk _0336_ VGND VGND VPWR VPWR memory\[12\]\[11\] sky130_fd_sc_hd__dfxtp_1
X_4945_ _2456_ _2505_ _2518_ VGND VGND VPWR VPWR _0521_ sky130_fd_sc_hd__a21o_1
X_7733_ clknet_leaf_111_clk _0267_ VGND VGND VPWR VPWR memory\[22\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_117_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_115_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4876_ net39 VGND VGND VPWR VPWR _2487_ sky130_fd_sc_hd__buf_4
XFILLER_0_74_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7664_ clknet_leaf_115_clk _0198_ VGND VGND VPWR VPWR memory\[21\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_7595_ clknet_leaf_23_clk _0129_ VGND VGND VPWR VPWR memory\[23\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_6_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3827_ _1397_ _1516_ _1401_ VGND VGND VPWR VPWR _1517_ sky130_fd_sc_hd__o21a_1
X_6615_ _2650_ _3371_ _3372_ net261 VGND VGND VPWR VPWR _0312_ sky130_fd_sc_hd__a22o_1
XFILLER_0_61_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6546_ net984 _3333_ _3338_ _3342_ VGND VGND VPWR VPWR _0273_ sky130_fd_sc_hd__a31o_1
X_3758_ _1443_ _1451_ VGND VGND VPWR VPWR _1452_ sky130_fd_sc_hd__and2_1
X_6477_ _2872_ _3295_ VGND VGND VPWR VPWR _3302_ sky130_fd_sc_hd__and2_1
X_3689_ memory\[0\]\[9\] memory\[1\]\[9\] memory\[2\]\[9\] memory\[3\]\[9\] _1271_
+ _1272_ VGND VGND VPWR VPWR _1386_ sky130_fd_sc_hd__mux4_1
X_5428_ _2473_ _2761_ _2762_ net379 VGND VGND VPWR VPWR _0760_ sky130_fd_sc_hd__a22o_1
XFILLER_0_100_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5359_ _2487_ _2738_ _2740_ net1057 VGND VGND VPWR VPWR _0708_ sky130_fd_sc_hd__a22o_1
X_7029_ clknet_leaf_112_clk _0620_ VGND VGND VPWR VPWR memory\[16\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_97_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_77_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_103_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_568 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_0_16 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f__2783_ clknet_0__2783_ VGND VGND VPWR VPWR clknet_1_0__leaf__2783_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_61_13 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_56_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4730_ memory\[28\]\[28\] memory\[29\]\[28\] memory\[30\]\[28\] memory\[31\]\[28\]
+ _1814_ _1816_ VGND VGND VPWR VPWR _2376_ sky130_fd_sc_hd__mux4_1
XTAP_1491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4661_ memory\[4\]\[24\] memory\[5\]\[24\] memory\[6\]\[24\] memory\[7\]\[24\] _1813_
+ _1815_ VGND VGND VPWR VPWR _2311_ sky130_fd_sc_hd__mux4_1
X_3612_ _1156_ VGND VGND VPWR VPWR _1312_ sky130_fd_sc_hd__buf_4
XFILLER_0_9_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6400_ net300 _3249_ _3250_ _3257_ VGND VGND VPWR VPWR _0212_ sky130_fd_sc_hd__a31o_1
XFILLER_0_4_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_7380_ clknet_leaf_0_clk _0939_ VGND VGND VPWR VPWR memory\[25\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_43_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4592_ _2101_ _2245_ VGND VGND VPWR VPWR _2246_ sky130_fd_sc_hd__or2_1
Xhold904 memory\[10\]\[3\] VGND VGND VPWR VPWR net1113 sky130_fd_sc_hd__dlygate4sd3_1
X_6331_ _2623_ _3226_ _3228_ net615 VGND VGND VPWR VPWR _0172_ sky130_fd_sc_hd__a22o_1
XFILLER_0_24_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold926 memory\[10\]\[25\] VGND VGND VPWR VPWR net1135 sky130_fd_sc_hd__dlygate4sd3_1
X_3543_ _1189_ VGND VGND VPWR VPWR _1247_ sky130_fd_sc_hd__clkbuf_8
Xhold915 memory\[25\]\[9\] VGND VGND VPWR VPWR net1124 sky130_fd_sc_hd__dlygate4sd3_1
Xhold937 memory\[25\]\[1\] VGND VGND VPWR VPWR net1146 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_10_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold948 memory\[25\]\[3\] VGND VGND VPWR VPWR net1157 sky130_fd_sc_hd__dlygate4sd3_1
Xhold959 memory\[6\]\[16\] VGND VGND VPWR VPWR net1168 sky130_fd_sc_hd__dlygate4sd3_1
X_6262_ net654 _3187_ _3182_ _3192_ VGND VGND VPWR VPWR _0139_ sky130_fd_sc_hd__a31o_1
X_3474_ memory\[28\]\[0\] memory\[29\]\[0\] memory\[30\]\[0\] memory\[31\]\[0\] _1178_
+ _1179_ VGND VGND VPWR VPWR _1180_ sky130_fd_sc_hd__mux4_1
X_6193_ net586 _3146_ _3138_ _3152_ VGND VGND VPWR VPWR _1135_ sky130_fd_sc_hd__a31o_1
X_5213_ _2461_ _2683_ _2685_ net950 VGND VGND VPWR VPWR _0622_ sky130_fd_sc_hd__a22o_1
X_5144_ net22 VGND VGND VPWR VPWR _2642_ sky130_fd_sc_hd__buf_4
X_5075_ _2483_ _2584_ _2593_ VGND VGND VPWR VPWR _0576_ sky130_fd_sc_hd__a21o_1
X_4026_ _1483_ _1705_ VGND VGND VPWR VPWR _1706_ sky130_fd_sc_hd__or2_1
XFILLER_0_66_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_leaf_91_clk clknet_4_5_0_clk VGND VGND VPWR VPWR clknet_leaf_91_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_94_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5977_ _2868_ _3023_ VGND VGND VPWR VPWR _3028_ sky130_fd_sc_hd__and2_1
X_7716_ clknet_leaf_65_clk _0250_ VGND VGND VPWR VPWR memory\[5\]\[21\] sky130_fd_sc_hd__dfxtp_1
X_4928_ _2504_ VGND VGND VPWR VPWR _2505_ sky130_fd_sc_hd__clkbuf_4
X_7647_ clknet_leaf_87_clk _0181_ VGND VGND VPWR VPWR memory\[19\]\[16\] sky130_fd_sc_hd__dfxtp_1
X_4859_ _2478_ _2476_ _2477_ net608 VGND VGND VPWR VPWR _0474_ sky130_fd_sc_hd__a22o_1
XFILLER_0_105_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7578_ clknet_leaf_109_clk _1137_ VGND VGND VPWR VPWR memory\[23\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_43_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6529_ net767 _3317_ _3324_ _3332_ VGND VGND VPWR VPWR _0266_ sky130_fd_sc_hd__a31o_1
XFILLER_0_43_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_97_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_leaf_82_clk clknet_4_7_0_clk VGND VGND VPWR VPWR clknet_leaf_82_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_57_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_122_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_237 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_0_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_13 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5900_ net544 _2981_ _2977_ _2983_ VGND VGND VPWR VPWR _1011_ sky130_fd_sc_hd__a31o_1
XFILLER_0_88_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_73_clk clknet_4_12_0_clk VGND VGND VPWR VPWR clknet_leaf_73_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_72_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6880_ clknet_leaf_85_clk _0471_ VGND VGND VPWR VPWR memory\[28\]\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_69_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5831_ _2472_ _2933_ _2942_ VGND VGND VPWR VPWR _0951_ sky130_fd_sc_hd__a21o_1
X_5762_ _2909_ VGND VGND VPWR VPWR _2913_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_118_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4713_ _2116_ _2359_ _2118_ VGND VGND VPWR VPWR _2360_ sky130_fd_sc_hd__o21a_1
X_7501_ clknet_leaf_17_clk _1060_ VGND VGND VPWR VPWR memory\[24\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_71_210 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5693_ _2870_ _2859_ VGND VGND VPWR VPWR _2871_ sky130_fd_sc_hd__and2_1
X_4644_ memory\[0\]\[23\] memory\[1\]\[23\] memory\[2\]\[23\] memory\[3\]\[23\] _1863_
+ _1864_ VGND VGND VPWR VPWR _2295_ sky130_fd_sc_hd__mux4_1
X_7432_ clknet_leaf_66_clk net120 VGND VGND VPWR VPWR memory\[0\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_71_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7363_ clknet_leaf_36_clk _0922_ VGND VGND VPWR VPWR memory\[18\]\[20\] sky130_fd_sc_hd__dfxtp_1
X_4575_ memory\[0\]\[19\] memory\[1\]\[19\] memory\[2\]\[19\] memory\[3\]\[19\] _1845_
+ _1846_ VGND VGND VPWR VPWR _2230_ sky130_fd_sc_hd__mux4_1
Xhold701 memory\[8\]\[13\] VGND VGND VPWR VPWR net910 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_4_565 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold712 memory\[16\]\[15\] VGND VGND VPWR VPWR net921 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_31_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold723 memory\[14\]\[29\] VGND VGND VPWR VPWR net932 sky130_fd_sc_hd__dlygate4sd3_1
X_6314_ net971 _3213_ _3209_ _3221_ VGND VGND VPWR VPWR _0162_ sky130_fd_sc_hd__a31o_1
X_7294_ clknet_leaf_76_clk _0853_ VGND VGND VPWR VPWR memory\[8\]\[15\] sky130_fd_sc_hd__dfxtp_1
Xhold734 memory\[23\]\[19\] VGND VGND VPWR VPWR net943 sky130_fd_sc_hd__dlygate4sd3_1
Xhold745 memory\[20\]\[11\] VGND VGND VPWR VPWR net954 sky130_fd_sc_hd__dlygate4sd3_1
X_3526_ _1228_ _1229_ _1166_ VGND VGND VPWR VPWR _1230_ sky130_fd_sc_hd__mux2_1
XFILLER_0_24_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold756 memory\[23\]\[29\] VGND VGND VPWR VPWR net965 sky130_fd_sc_hd__dlygate4sd3_1
Xhold778 memory\[4\]\[5\] VGND VGND VPWR VPWR net987 sky130_fd_sc_hd__dlygate4sd3_1
Xhold767 memory\[7\]\[7\] VGND VGND VPWR VPWR net976 sky130_fd_sc_hd__dlygate4sd3_1
X_6245_ _3181_ VGND VGND VPWR VPWR _3182_ sky130_fd_sc_hd__clkbuf_4
Xhold789 memory\[16\]\[31\] VGND VGND VPWR VPWR net998 sky130_fd_sc_hd__dlygate4sd3_1
X_3457_ memory\[16\]\[0\] memory\[17\]\[0\] memory\[18\]\[0\] memory\[19\]\[0\] _1161_
+ _1162_ VGND VGND VPWR VPWR _1163_ sky130_fd_sc_hd__mux4_1
X_6176_ _2840_ _3140_ VGND VGND VPWR VPWR _3143_ sky130_fd_sc_hd__and2_1
X_5127_ _2605_ VGND VGND VPWR VPWR _2630_ sky130_fd_sc_hd__buf_4
X_5058_ _2474_ _2571_ _2583_ VGND VGND VPWR VPWR _0569_ sky130_fd_sc_hd__a21o_1
X_4009_ memory\[12\]\[25\] memory\[13\]\[25\] memory\[14\]\[25\] memory\[15\]\[25\]
+ _1430_ _1431_ VGND VGND VPWR VPWR _1690_ sky130_fd_sc_hd__mux4_1
Xclkbuf_leaf_64_clk clknet_4_13_0_clk VGND VGND VPWR VPWR clknet_leaf_64_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_67_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_81 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_47_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_118_684 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_105_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_232 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_62_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_120_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold50 memory\[16\]\[24\] VGND VGND VPWR VPWR net259 sky130_fd_sc_hd__dlygate4sd3_1
Xhold72 memory\[19\]\[20\] VGND VGND VPWR VPWR net281 sky130_fd_sc_hd__dlygate4sd3_1
Xhold61 memory\[9\]\[31\] VGND VGND VPWR VPWR net270 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_26_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold83 memory\[31\]\[11\] VGND VGND VPWR VPWR net292 sky130_fd_sc_hd__dlygate4sd3_1
Xhold94 memory\[13\]\[25\] VGND VGND VPWR VPWR net303 sky130_fd_sc_hd__dlygate4sd3_1
Xclkbuf_leaf_55_clk clknet_4_14_0_clk VGND VGND VPWR VPWR clknet_leaf_55_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_73_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_109_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_41_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_3 _1168_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4360_ _2013_ _2025_ VGND VGND VPWR VPWR _2026_ sky130_fd_sc_hd__and2_1
XFILLER_0_6_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_111_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4291_ _1811_ VGND VGND VPWR VPWR _1959_ sky130_fd_sc_hd__buf_6
XTAP_324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6030_ net931 _3047_ _3051_ _3058_ VGND VGND VPWR VPWR _1066_ sky130_fd_sc_hd__a31o_1
XTAP_379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_107_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_83_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_46_clk clknet_4_12_0_clk VGND VGND VPWR VPWR clknet_leaf_46_clk sky130_fd_sc_hd__clkbuf_16
X_6932_ clknet_leaf_12_clk _0523_ VGND VGND VPWR VPWR memory\[10\]\[5\] sky130_fd_sc_hd__dfxtp_1
XPHY_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6863_ clknet_leaf_5_clk _0454_ VGND VGND VPWR VPWR memory\[28\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_5814_ _2918_ VGND VGND VPWR VPWR _2933_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_9_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_6794_ _2613_ _3438_ _3440_ net384 VGND VGND VPWR VPWR _0423_ sky130_fd_sc_hd__a22o_1
X_5745_ net852 _2890_ _2832_ _2906_ VGND VGND VPWR VPWR _0901_ sky130_fd_sc_hd__a31o_1
XFILLER_0_96_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_17_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5676_ _2835_ VGND VGND VPWR VPWR _2859_ sky130_fd_sc_hd__buf_2
X_4627_ memory\[12\]\[22\] memory\[13\]\[22\] memory\[14\]\[22\] memory\[15\]\[22\]
+ _1973_ _1974_ VGND VGND VPWR VPWR _2279_ sky130_fd_sc_hd__mux4_1
XFILLER_0_32_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7415_ clknet_leaf_102_clk net137 VGND VGND VPWR VPWR memory\[0\]\[8\] sky130_fd_sc_hd__dfxtp_1
Xhold520 memory\[12\]\[8\] VGND VGND VPWR VPWR net729 sky130_fd_sc_hd__dlygate4sd3_1
Xhold553 memory\[11\]\[19\] VGND VGND VPWR VPWR net762 sky130_fd_sc_hd__dlygate4sd3_1
Xhold542 memory\[15\]\[3\] VGND VGND VPWR VPWR net751 sky130_fd_sc_hd__dlygate4sd3_1
X_4558_ _2097_ _2209_ _2211_ _2213_ _2066_ VGND VGND VPWR VPWR _2214_ sky130_fd_sc_hd__a221o_1
Xhold531 memory\[9\]\[9\] VGND VGND VPWR VPWR net740 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_7346_ clknet_leaf_0_clk _0905_ VGND VGND VPWR VPWR memory\[18\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_40_460 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold586 memory\[26\]\[26\] VGND VGND VPWR VPWR net795 sky130_fd_sc_hd__dlygate4sd3_1
Xhold575 memory\[3\]\[18\] VGND VGND VPWR VPWR net784 sky130_fd_sc_hd__dlygate4sd3_1
X_7277_ net180 _0023_ VGND VGND VPWR VPWR net105 sky130_fd_sc_hd__dfxtp_2
X_4489_ memory\[16\]\[15\] memory\[17\]\[15\] memory\[18\]\[15\] memory\[19\]\[15\]
+ _2028_ _2029_ VGND VGND VPWR VPWR _2148_ sky130_fd_sc_hd__mux4_1
Xhold564 memory\[5\]\[6\] VGND VGND VPWR VPWR net773 sky130_fd_sc_hd__dlygate4sd3_1
Xhold597 memory\[7\]\[9\] VGND VGND VPWR VPWR net806 sky130_fd_sc_hd__dlygate4sd3_1
X_3509_ memory\[24\]\[1\] memory\[25\]\[1\] memory\[26\]\[1\] memory\[27\]\[1\] _1171_
+ _1173_ VGND VGND VPWR VPWR _1214_ sky130_fd_sc_hd__mux4_1
XFILLER_0_110_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6228_ _2891_ _3167_ VGND VGND VPWR VPWR _3173_ sky130_fd_sc_hd__and2_1
X_6159_ net1048 _3130_ _3122_ _3132_ VGND VGND VPWR VPWR _1121_ sky130_fd_sc_hd__a31o_1
XTAP_880 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_891 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_37_clk clknet_4_11_0_clk VGND VGND VPWR VPWR clknet_leaf_37_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_95_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_530 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_12_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_106_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_106_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_235 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_121_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput51 net51 VGND VGND VPWR VPWR data_out1[10] sky130_fd_sc_hd__clkbuf_4
Xoutput84 net84 VGND VGND VPWR VPWR data_out2[11] sky130_fd_sc_hd__clkbuf_4
Xoutput62 net62 VGND VGND VPWR VPWR data_out1[20] sky130_fd_sc_hd__clkbuf_4
Xoutput73 net73 VGND VGND VPWR VPWR data_out1[30] sky130_fd_sc_hd__clkbuf_4
Xoutput95 net95 VGND VGND VPWR VPWR data_out2[21] sky130_fd_sc_hd__clkbuf_4
Xclkbuf_leaf_28_clk clknet_4_10_0_clk VGND VGND VPWR VPWR clknet_leaf_28_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_98_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3860_ _1158_ VGND VGND VPWR VPWR _1548_ sky130_fd_sc_hd__buf_6
XFILLER_0_116_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3791_ _1168_ VGND VGND VPWR VPWR _1483_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_116_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5461_ _2463_ _2770_ _2771_ net553 VGND VGND VPWR VPWR _0784_ sky130_fd_sc_hd__a22o_1
X_7200_ clknet_leaf_67_clk _0791_ VGND VGND VPWR VPWR memory\[14\]\[17\] sky130_fd_sc_hd__dfxtp_1
X_4412_ _2073_ _2074_ _1976_ VGND VGND VPWR VPWR _2075_ sky130_fd_sc_hd__mux2_1
XFILLER_0_112_668 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5392_ _2478_ _2754_ _2755_ net478 VGND VGND VPWR VPWR _0731_ sky130_fd_sc_hd__a22o_1
XFILLER_0_10_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4343_ _1964_ _2008_ _1968_ VGND VGND VPWR VPWR _2009_ sky130_fd_sc_hd__o21a_1
X_7131_ clknet_leaf_80_clk _0722_ VGND VGND VPWR VPWR memory\[3\]\[12\] sky130_fd_sc_hd__dfxtp_1
X_7062_ clknet_leaf_111_clk _0653_ VGND VGND VPWR VPWR memory\[4\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_4274_ memory\[24\]\[5\] memory\[25\]\[5\] memory\[26\]\[5\] memory\[27\]\[5\] _1814_
+ _1816_ VGND VGND VPWR VPWR _1943_ sky130_fd_sc_hd__mux4_1
X_6013_ _2903_ _3009_ VGND VGND VPWR VPWR _3048_ sky130_fd_sc_hd__and2_1
XFILLER_0_10_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_118_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_19_clk clknet_4_8_0_clk VGND VGND VPWR VPWR clknet_leaf_19_clk sky130_fd_sc_hd__clkbuf_16
X_6915_ clknet_leaf_54_clk _0506_ VGND VGND VPWR VPWR memory\[15\]\[21\] sky130_fd_sc_hd__dfxtp_1
XTAP_1309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_7895_ clknet_leaf_111_clk _0429_ VGND VGND VPWR VPWR memory\[17\]\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_77_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6777_ _2659_ _3434_ _3435_ net416 VGND VGND VPWR VPWR _0411_ sky130_fd_sc_hd__a22o_1
XFILLER_0_91_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5728_ net34 VGND VGND VPWR VPWR _2895_ sky130_fd_sc_hd__buf_4
X_3989_ _1205_ _1670_ _1153_ VGND VGND VPWR VPWR _1671_ sky130_fd_sc_hd__o21a_1
XFILLER_0_9_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5659_ net43 VGND VGND VPWR VPWR _2847_ sky130_fd_sc_hd__clkbuf_4
Xhold350 memory\[8\]\[27\] VGND VGND VPWR VPWR net559 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_102_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold361 memory\[27\]\[10\] VGND VGND VPWR VPWR net570 sky130_fd_sc_hd__dlygate4sd3_1
X_7329_ clknet_leaf_85_clk _0888_ VGND VGND VPWR VPWR memory\[7\]\[18\] sky130_fd_sc_hd__dfxtp_1
Xhold372 memory\[28\]\[28\] VGND VGND VPWR VPWR net581 sky130_fd_sc_hd__dlygate4sd3_1
Xhold394 memory\[13\]\[1\] VGND VGND VPWR VPWR net603 sky130_fd_sc_hd__dlygate4sd3_1
Xhold383 memory\[28\]\[3\] VGND VGND VPWR VPWR net592 sky130_fd_sc_hd__dlygate4sd3_1
Xclkbuf_4_13_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_13_0_clk sky130_fd_sc_hd__clkbuf_8
XTAP_1843 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1832 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1821 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1810 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1865 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1854 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_68_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_78_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4961_ _2463_ _2525_ _2527_ VGND VGND VPWR VPWR _0528_ sky130_fd_sc_hd__a21o_1
X_3912_ _1584_ _1587_ _1590_ _1596_ _1597_ VGND VGND VPWR VPWR _1598_ sky130_fd_sc_hd__a221o_1
XFILLER_0_86_463 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4892_ _2457_ _2494_ _2496_ net671 VGND VGND VPWR VPWR _0489_ sky130_fd_sc_hd__a22o_1
XFILLER_0_58_176 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_7680_ clknet_leaf_108_clk _0214_ VGND VGND VPWR VPWR memory\[21\]\[17\] sky130_fd_sc_hd__dfxtp_1
X_6700_ net776 _3393_ _3400_ _3402_ VGND VGND VPWR VPWR _0367_ sky130_fd_sc_hd__a31o_1
XFILLER_0_117_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6631_ _3375_ VGND VGND VPWR VPWR _3376_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_73_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3843_ memory\[24\]\[17\] memory\[25\]\[17\] memory\[26\]\[17\] memory\[27\]\[17\]
+ _1353_ _1354_ VGND VGND VPWR VPWR _1532_ sky130_fd_sc_hd__mux4_1
XFILLER_0_39_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_116_215 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_104_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6562_ _3323_ VGND VGND VPWR VPWR _3351_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_73_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3774_ _1250_ _1466_ _1254_ VGND VGND VPWR VPWR _1467_ sky130_fd_sc_hd__o21a_1
XFILLER_0_14_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5513_ _2777_ VGND VGND VPWR VPWR _2782_ sky130_fd_sc_hd__clkbuf_4
X_6493_ net968 _3304_ _3307_ _3311_ VGND VGND VPWR VPWR _0251_ sky130_fd_sc_hd__a31o_1
XFILLER_0_42_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_112_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5444_ _2489_ _2491_ _2501_ VGND VGND VPWR VPWR _2765_ sky130_fd_sc_hd__and3_1
Xclkbuf_leaf_8_clk clknet_4_2_0_clk VGND VGND VPWR VPWR clknet_leaf_8_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_14_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_599 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_112_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7114_ clknet_leaf_34_clk _0705_ VGND VGND VPWR VPWR memory\[29\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_59_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_1_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5375_ _2461_ _2749_ _2751_ net430 VGND VGND VPWR VPWR _0718_ sky130_fd_sc_hd__a22o_1
XFILLER_0_10_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4326_ memory\[20\]\[7\] memory\[21\]\[7\] memory\[22\]\[7\] memory\[23\]\[7\] _1831_
+ _1833_ VGND VGND VPWR VPWR _1993_ sky130_fd_sc_hd__mux4_1
X_7045_ clknet_leaf_39_clk _0636_ VGND VGND VPWR VPWR memory\[16\]\[22\] sky130_fd_sc_hd__dfxtp_1
X_4257_ _1820_ _1926_ _1824_ VGND VGND VPWR VPWR _1927_ sky130_fd_sc_hd__o21a_1
X_4188_ _1798_ _1856_ _1858_ _1860_ _1827_ VGND VGND VPWR VPWR _1861_ sky130_fd_sc_hd__a221o_1
XFILLER_0_96_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_1128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7947_ net146 _0052_ VGND VGND VPWR VPWR net70 sky130_fd_sc_hd__dfxtp_2
X_7878_ clknet_leaf_59_clk _0412_ VGND VGND VPWR VPWR memory\[13\]\[23\] sky130_fd_sc_hd__dfxtp_1
XTAP_1139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_122_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_115_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold180 memory\[24\]\[18\] VGND VGND VPWR VPWR net389 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_109_19 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold191 memory\[22\]\[3\] VGND VGND VPWR VPWR net400 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_55_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_59 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_70_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_63_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_51_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3490_ memory\[12\]\[0\] memory\[13\]\[0\] memory\[14\]\[0\] memory\[15\]\[0\] _1194_
+ _1195_ VGND VGND VPWR VPWR _1196_ sky130_fd_sc_hd__mux4_2
X_5160_ _2605_ VGND VGND VPWR VPWR _2653_ sky130_fd_sc_hd__clkbuf_4
X_5091_ _2502_ _2603_ VGND VGND VPWR VPWR _2604_ sky130_fd_sc_hd__or2b_1
X_4111_ _1236_ _1781_ _1783_ _1785_ _1183_ VGND VGND VPWR VPWR _1786_ sky130_fd_sc_hd__a221o_1
X_4042_ memory\[12\]\[27\] memory\[13\]\[27\] memory\[14\]\[27\] memory\[15\]\[27\]
+ _1188_ _1190_ VGND VGND VPWR VPWR _1721_ sky130_fd_sc_hd__mux4_1
XFILLER_0_79_706 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_78_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5993_ net390 _3034_ _3035_ _3037_ VGND VGND VPWR VPWR _1050_ sky130_fd_sc_hd__a31o_1
X_7801_ clknet_leaf_71_clk _0335_ VGND VGND VPWR VPWR memory\[12\]\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_115_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4944_ net1113 _2516_ _2513_ VGND VGND VPWR VPWR _2518_ sky130_fd_sc_hd__and3_1
X_7732_ clknet_leaf_114_clk _0266_ VGND VGND VPWR VPWR memory\[22\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_24_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4875_ _2486_ _2476_ _2477_ net288 VGND VGND VPWR VPWR _0482_ sky130_fd_sc_hd__a22o_1
X_7663_ clknet_leaf_115_clk _0197_ VGND VGND VPWR VPWR memory\[21\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_117_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7594_ clknet_leaf_27_clk _0128_ VGND VGND VPWR VPWR memory\[23\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_74_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3826_ memory\[28\]\[16\] memory\[29\]\[16\] memory\[30\]\[16\] memory\[31\]\[16\]
+ _1398_ _1399_ VGND VGND VPWR VPWR _1516_ sky130_fd_sc_hd__mux4_1
X_6614_ _2648_ _3371_ _3372_ net295 VGND VGND VPWR VPWR _0311_ sky130_fd_sc_hd__a22o_1
X_6545_ _2863_ _3339_ VGND VGND VPWR VPWR _3342_ sky130_fd_sc_hd__and2_1
XFILLER_0_42_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3757_ _1445_ _1447_ _1450_ _1207_ _1412_ VGND VGND VPWR VPWR _1451_ sky130_fd_sc_hd__a221o_1
XFILLER_0_70_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_672 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6476_ net980 _3291_ _3294_ _3301_ VGND VGND VPWR VPWR _0244_ sky130_fd_sc_hd__a31o_1
X_3688_ memory\[4\]\[9\] memory\[5\]\[9\] memory\[6\]\[9\] memory\[7\]\[9\] _1199_
+ _1200_ VGND VGND VPWR VPWR _1385_ sky130_fd_sc_hd__mux4_1
X_5427_ _2472_ _2761_ _2762_ net892 VGND VGND VPWR VPWR _0759_ sky130_fd_sc_hd__a22o_1
XFILLER_0_2_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_493 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5358_ _2486_ _2744_ _2745_ net628 VGND VGND VPWR VPWR _0707_ sky130_fd_sc_hd__a22o_1
X_4309_ _1972_ _1975_ _1976_ VGND VGND VPWR VPWR _1977_ sky130_fd_sc_hd__mux2_1
X_7028_ clknet_leaf_113_clk _0619_ VGND VGND VPWR VPWR memory\[16\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_5289_ _2650_ _2708_ VGND VGND VPWR VPWR _2719_ sky130_fd_sc_hd__and2_1
XFILLER_0_65_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_108_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_92_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4660_ _2086_ _2305_ _2307_ _2309_ _2223_ VGND VGND VPWR VPWR _2310_ sky130_fd_sc_hd__a221o_1
XFILLER_0_9_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_44_628 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_71_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3611_ _1311_ VGND VGND VPWR VPWR _0027_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_114_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4591_ memory\[8\]\[20\] memory\[9\]\[20\] memory\[10\]\[20\] memory\[11\]\[20\]
+ _1837_ _1838_ VGND VGND VPWR VPWR _2245_ sky130_fd_sc_hd__mux4_1
X_6330_ _2621_ _3226_ _3228_ net1039 VGND VGND VPWR VPWR _0171_ sky130_fd_sc_hd__a22o_1
XFILLER_0_24_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold927 memory\[6\]\[3\] VGND VGND VPWR VPWR net1136 sky130_fd_sc_hd__dlygate4sd3_1
Xhold916 memory\[6\]\[1\] VGND VGND VPWR VPWR net1125 sky130_fd_sc_hd__dlygate4sd3_1
Xhold905 memory\[6\]\[11\] VGND VGND VPWR VPWR net1114 sky130_fd_sc_hd__dlygate4sd3_1
X_3542_ _1187_ VGND VGND VPWR VPWR _1246_ sky130_fd_sc_hd__buf_8
Xhold938 memory\[6\]\[25\] VGND VGND VPWR VPWR net1147 sky130_fd_sc_hd__dlygate4sd3_1
Xhold949 memory\[10\]\[2\] VGND VGND VPWR VPWR net1158 sky130_fd_sc_hd__dlygate4sd3_1
X_6261_ _2849_ _3184_ VGND VGND VPWR VPWR _3192_ sky130_fd_sc_hd__and2_1
X_3473_ _1172_ VGND VGND VPWR VPWR _1179_ sky130_fd_sc_hd__clkbuf_4
X_6192_ _2855_ _3140_ VGND VGND VPWR VPWR _3152_ sky130_fd_sc_hd__and2_1
X_5212_ _2460_ _2683_ _2685_ net513 VGND VGND VPWR VPWR _0621_ sky130_fd_sc_hd__a22o_1
X_5143_ net696 _2629_ _2630_ _2641_ VGND VGND VPWR VPWR _0596_ sky130_fd_sc_hd__a31o_1
X_5074_ memory\[6\]\[26\] _2585_ _2586_ VGND VGND VPWR VPWR _2593_ sky130_fd_sc_hd__and3_1
X_4025_ memory\[8\]\[26\] memory\[9\]\[26\] memory\[10\]\[26\] memory\[11\]\[26\]
+ _1194_ _1195_ VGND VGND VPWR VPWR _1705_ sky130_fd_sc_hd__mux4_1
XFILLER_0_79_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5976_ net284 _3021_ _3022_ _3027_ VGND VGND VPWR VPWR _1043_ sky130_fd_sc_hd__a31o_1
XFILLER_0_117_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7715_ clknet_leaf_65_clk _0249_ VGND VGND VPWR VPWR memory\[5\]\[20\] sky130_fd_sc_hd__dfxtp_1
X_4927_ _2502_ _2503_ VGND VGND VPWR VPWR _2504_ sky130_fd_sc_hd__nor2_2
XFILLER_0_47_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4858_ net29 VGND VGND VPWR VPWR _2478_ sky130_fd_sc_hd__buf_4
XFILLER_0_90_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_7646_ clknet_leaf_89_clk _0180_ VGND VGND VPWR VPWR memory\[19\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_34_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3809_ memory\[8\]\[15\] memory\[9\]\[15\] memory\[10\]\[15\] memory\[11\]\[15\]
+ _1202_ _1203_ VGND VGND VPWR VPWR _1500_ sky130_fd_sc_hd__mux4_1
X_4789_ memory\[12\]\[31\] memory\[13\]\[31\] memory\[14\]\[31\] memory\[15\]\[31\]
+ _1814_ _1816_ VGND VGND VPWR VPWR _2432_ sky130_fd_sc_hd__mux4_1
X_5553__28 clknet_1_1__leaf__2786_ VGND VGND VPWR VPWR net173 sky130_fd_sc_hd__inv_2
X_7577_ clknet_leaf_94_clk _1136_ VGND VGND VPWR VPWR memory\[23\]\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_27_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6528_ _2847_ _3326_ VGND VGND VPWR VPWR _3332_ sky130_fd_sc_hd__and2_1
XFILLER_0_30_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6459_ _2853_ _3282_ VGND VGND VPWR VPWR _3292_ sky130_fd_sc_hd__and2_1
XFILLER_0_100_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_122_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_108_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_108_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5830_ net1165 _2930_ _2934_ VGND VGND VPWR VPWR _2942_ sky130_fd_sc_hd__and3_1
XFILLER_0_118_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_118_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5761_ _2627_ _2910_ _2912_ net895 VGND VGND VPWR VPWR _0911_ sky130_fd_sc_hd__a22o_1
X_4712_ memory\[28\]\[27\] memory\[29\]\[27\] memory\[30\]\[27\] memory\[31\]\[27\]
+ _1814_ _1816_ VGND VGND VPWR VPWR _2359_ sky130_fd_sc_hd__mux4_1
X_7500_ clknet_leaf_28_clk _1059_ VGND VGND VPWR VPWR memory\[24\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_56_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_112_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7431_ clknet_leaf_60_clk net121 VGND VGND VPWR VPWR memory\[0\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_71_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5692_ net22 VGND VGND VPWR VPWR _2870_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_112_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4643_ memory\[4\]\[23\] memory\[5\]\[23\] memory\[6\]\[23\] memory\[7\]\[23\] _1813_
+ _1815_ VGND VGND VPWR VPWR _2294_ sky130_fd_sc_hd__mux4_1
XFILLER_0_71_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_102_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4574_ memory\[4\]\[19\] memory\[5\]\[19\] memory\[6\]\[19\] memory\[7\]\[19\] _1842_
+ _1843_ VGND VGND VPWR VPWR _2229_ sky130_fd_sc_hd__mux4_1
XFILLER_0_4_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold702 memory\[7\]\[1\] VGND VGND VPWR VPWR net911 sky130_fd_sc_hd__dlygate4sd3_1
X_7362_ clknet_leaf_98_clk _0921_ VGND VGND VPWR VPWR memory\[18\]\[19\] sky130_fd_sc_hd__dfxtp_1
Xhold735 memory\[2\]\[20\] VGND VGND VPWR VPWR net944 sky130_fd_sc_hd__dlygate4sd3_1
X_6313_ _2901_ _3210_ VGND VGND VPWR VPWR _3221_ sky130_fd_sc_hd__and2_1
XFILLER_0_97_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold724 memory\[14\]\[7\] VGND VGND VPWR VPWR net933 sky130_fd_sc_hd__dlygate4sd3_1
X_7293_ clknet_leaf_81_clk _0852_ VGND VGND VPWR VPWR memory\[8\]\[14\] sky130_fd_sc_hd__dfxtp_1
Xhold746 memory\[20\]\[8\] VGND VGND VPWR VPWR net955 sky130_fd_sc_hd__dlygate4sd3_1
Xhold713 memory\[16\]\[10\] VGND VGND VPWR VPWR net922 sky130_fd_sc_hd__dlygate4sd3_1
X_3525_ memory\[16\]\[2\] memory\[17\]\[2\] memory\[18\]\[2\] memory\[19\]\[2\] _1161_
+ _1162_ VGND VGND VPWR VPWR _1229_ sky130_fd_sc_hd__mux4_1
X_6244_ _2831_ _2603_ VGND VGND VPWR VPWR _3181_ sky130_fd_sc_hd__nand2_4
Xhold779 memory\[9\]\[18\] VGND VGND VPWR VPWR net988 sky130_fd_sc_hd__dlygate4sd3_1
Xhold757 memory\[5\]\[11\] VGND VGND VPWR VPWR net966 sky130_fd_sc_hd__dlygate4sd3_1
Xhold768 memory\[7\]\[19\] VGND VGND VPWR VPWR net977 sky130_fd_sc_hd__dlygate4sd3_1
X_3456_ _1158_ VGND VGND VPWR VPWR _1162_ sky130_fd_sc_hd__buf_4
X_6175_ net1054 _3130_ _3138_ _3142_ VGND VGND VPWR VPWR _1127_ sky130_fd_sc_hd__a31o_1
XFILLER_0_41_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5126_ _2600_ VGND VGND VPWR VPWR _2629_ sky130_fd_sc_hd__clkbuf_4
X_5057_ memory\[6\]\[19\] _2572_ _2573_ VGND VGND VPWR VPWR _2583_ sky130_fd_sc_hd__and3_1
X_4008_ _1483_ _1688_ VGND VGND VPWR VPWR _1689_ sky130_fd_sc_hd__or2_1
XFILLER_0_79_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_93 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5959_ net763 _3006_ _3008_ _3017_ VGND VGND VPWR VPWR _1036_ sky130_fd_sc_hd__a31o_1
XFILLER_0_63_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_118_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7629_ clknet_leaf_21_clk _0163_ VGND VGND VPWR VPWR memory\[27\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_62_266 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_62_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold40 memory\[27\]\[1\] VGND VGND VPWR VPWR net249 sky130_fd_sc_hd__dlygate4sd3_1
Xhold73 memory\[29\]\[26\] VGND VGND VPWR VPWR net282 sky130_fd_sc_hd__dlygate4sd3_1
Xhold51 memory\[12\]\[20\] VGND VGND VPWR VPWR net260 sky130_fd_sc_hd__dlygate4sd3_1
Xhold62 memory\[17\]\[18\] VGND VGND VPWR VPWR net271 sky130_fd_sc_hd__dlygate4sd3_1
Xhold95 memory\[12\]\[27\] VGND VGND VPWR VPWR net304 sky130_fd_sc_hd__dlygate4sd3_1
Xhold84 memory\[3\]\[15\] VGND VGND VPWR VPWR net293 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_98_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_230 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_109_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_54_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_109_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_108_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_4 _1170_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4290_ _1958_ VGND VGND VPWR VPWR _0059_ sky130_fd_sc_hd__buf_1
XTAP_314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6931_ clknet_leaf_8_clk _0522_ VGND VGND VPWR VPWR memory\[10\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_107_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6862_ clknet_leaf_9_clk _0453_ VGND VGND VPWR VPWR memory\[28\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_5813_ _2462_ _2919_ _2932_ VGND VGND VPWR VPWR _0943_ sky130_fd_sc_hd__a21o_1
XFILLER_0_57_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6793_ _2611_ _3438_ _3440_ net503 VGND VGND VPWR VPWR _0422_ sky130_fd_sc_hd__a22o_1
X_5744_ _2905_ _2835_ VGND VGND VPWR VPWR _2906_ sky130_fd_sc_hd__and2_1
XFILLER_0_44_211 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_115_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5675_ net17 VGND VGND VPWR VPWR _2858_ sky130_fd_sc_hd__clkbuf_4
X_4626_ _1811_ _2277_ VGND VGND VPWR VPWR _2278_ sky130_fd_sc_hd__or2_1
XFILLER_0_89_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_7414_ clknet_leaf_106_clk net138 VGND VGND VPWR VPWR memory\[0\]\[7\] sky130_fd_sc_hd__dfxtp_1
Xhold510 memory\[12\]\[14\] VGND VGND VPWR VPWR net719 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_4_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_7345_ clknet_leaf_116_clk _0904_ VGND VGND VPWR VPWR memory\[18\]\[2\] sky130_fd_sc_hd__dfxtp_1
Xhold543 memory\[15\]\[20\] VGND VGND VPWR VPWR net752 sky130_fd_sc_hd__dlygate4sd3_1
Xhold532 memory\[3\]\[20\] VGND VGND VPWR VPWR net741 sky130_fd_sc_hd__dlygate4sd3_1
Xhold521 memory\[1\]\[31\] VGND VGND VPWR VPWR net730 sky130_fd_sc_hd__dlygate4sd3_1
X_4557_ _2104_ _2212_ _2106_ VGND VGND VPWR VPWR _2213_ sky130_fd_sc_hd__o21a_1
XFILLER_0_12_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold554 memory\[24\]\[6\] VGND VGND VPWR VPWR net763 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7276_ net179 _0021_ VGND VGND VPWR VPWR net103 sky130_fd_sc_hd__dfxtp_2
X_4488_ memory\[20\]\[15\] memory\[21\]\[15\] memory\[22\]\[15\] memory\[23\]\[15\]
+ _1938_ _1939_ VGND VGND VPWR VPWR _2147_ sky130_fd_sc_hd__mux4_1
Xhold587 memory\[20\]\[4\] VGND VGND VPWR VPWR net796 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold576 memory\[19\]\[5\] VGND VGND VPWR VPWR net785 sky130_fd_sc_hd__dlygate4sd3_1
X_3508_ _1211_ _1212_ _1166_ VGND VGND VPWR VPWR _1213_ sky130_fd_sc_hd__mux2_1
Xhold565 memory\[7\]\[12\] VGND VGND VPWR VPWR net774 sky130_fd_sc_hd__dlygate4sd3_1
Xhold598 memory\[9\]\[23\] VGND VGND VPWR VPWR net807 sky130_fd_sc_hd__dlygate4sd3_1
X_6227_ _3145_ VGND VGND VPWR VPWR _3172_ sky130_fd_sc_hd__buf_4
X_6158_ _2897_ _3123_ VGND VGND VPWR VPWR _3132_ sky130_fd_sc_hd__and2_1
XTAP_870 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5109_ _2617_ _2609_ VGND VGND VPWR VPWR _2618_ sky130_fd_sc_hd__and2_1
XTAP_881 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_892 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6089_ net392 _3088_ _3050_ _3091_ VGND VGND VPWR VPWR _1092_ sky130_fd_sc_hd__a31o_1
XFILLER_0_95_689 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_63_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_121_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput52 net52 VGND VGND VPWR VPWR data_out1[11] sky130_fd_sc_hd__clkbuf_4
Xoutput85 net85 VGND VGND VPWR VPWR data_out2[12] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_101_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput63 net63 VGND VGND VPWR VPWR data_out1[21] sky130_fd_sc_hd__clkbuf_4
Xoutput74 net74 VGND VGND VPWR VPWR data_out1[31] sky130_fd_sc_hd__clkbuf_4
Xoutput96 net96 VGND VGND VPWR VPWR data_out2[22] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_53_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3790_ _1480_ _1481_ _1243_ VGND VGND VPWR VPWR _1482_ sky130_fd_sc_hd__mux2_1
XFILLER_0_54_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5460_ _2768_ VGND VGND VPWR VPWR _2771_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_26_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4411_ memory\[16\]\[11\] memory\[17\]\[11\] memory\[18\]\[11\] memory\[19\]\[11\]
+ _1970_ _1971_ VGND VGND VPWR VPWR _2074_ sky130_fd_sc_hd__mux4_1
XFILLER_0_41_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5391_ _2475_ _2754_ _2755_ net741 VGND VGND VPWR VPWR _0730_ sky130_fd_sc_hd__a22o_1
XFILLER_0_78_45 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_75_9 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_1_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_450 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_10_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4342_ memory\[28\]\[8\] memory\[29\]\[8\] memory\[30\]\[8\] memory\[31\]\[8\] _1965_
+ _1966_ VGND VGND VPWR VPWR _2008_ sky130_fd_sc_hd__mux4_1
X_7130_ clknet_leaf_80_clk _0721_ VGND VGND VPWR VPWR memory\[3\]\[11\] sky130_fd_sc_hd__dfxtp_1
X_4273_ _1940_ _1941_ _1903_ VGND VGND VPWR VPWR _1942_ sky130_fd_sc_hd__mux2_1
X_7061_ clknet_leaf_106_clk _0652_ VGND VGND VPWR VPWR memory\[4\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_6012_ _3005_ VGND VGND VPWR VPWR _3047_ sky130_fd_sc_hd__clkbuf_4
.ends
